FILESEXTRAPATHS:prepend := "${THISDIR}/upports:"

COMPATIBLE_MACHINE:dh-stm32mp25-dhsom = "dh-stm32mp25-dhsom"
OPTEEMACHINE:dh-stm32mp25-dhsom = "stm32mp2-25XX_DHCOS_SOM "
EXTRA_OEMAKE:append:dh-stm32mp25-dhsom = " CFG_EMBED_DTB_SOURCE_FILE=stm32mp25xx-dhcos-som.dts "

# Workaround for ST downstream 0004-core-scmi-server-dump-source-files-from-SCP-firmware.patch
# which includes binary blobs in the patch file. OE default patchtool, quilt,
# rejects such bad patches. Work around this by using git to apply the patches.
PATCHTOOL:dh-stm32mp25-dhsom = "git"

DEPENDS:append:dh-stm32mp25-dhsom = " python3-pillow-native"

SRC_URI:append:dh-stm32mp25-dhsom = " \
	file://0001-CONTRIBUTING-add-contributing-guide.patch \
	file://0002-SECURITY-add-security-notice.patch \
	file://0003-README.md-add-security-advisories.patch \
	file://0004-core-scmi-server-dump-source-files-from-SCP-firmware.patch \
	file://0005-core-arm-add-notice-to-sm-psci.h-and-sm-std_smc.h.patch \
	file://0006-core-arm-add-guards-to-sm-psci.h.patch \
	file://0007-core-arm-add-guards-to-tz_proc_def.h.patch \
	file://0008-core-kernel-add-missing-guards-in-time_source.h.patch \
	file://0009-core-fix-header-file-guard-names.patch \
	file://0010-core-prefix-header-file-guard-names-with-__.patch \
	file://0011-scripts-Add-script-to-support-Language-Server-Protoc.patch \
	file://0012-ta-pkcs11-Improve-PIN-counter-handling-robustness.patch \
	file://0013-core-notif-upgrade-to-new-interrupt-framework.patch \
	file://0014-plat-stm32mp1-upgrade-to-new-interrupt-framework.patch \
	file://0015-core-interrupt-remove-old-API-functions.patch \
	file://0016-core-kernel-interrupt-fix-inline-description.patch \
	file://0017-core-io-fix-missing-include-of-delay.h.patch \
	file://0018-drivers-stm32_gpio-remove-unused-APIs.patch \
	file://0019-dts-stm32-introduce-STM32MP25-SoCs-family.patch \
	file://0020-dts-stm32-add-stm32mp257f-ev1-board-support.patch \
	file://0021-plat-stm32mp2-add-new-platform-support.patch \
	file://0022-MAINTAINERS-update-STMicroelectronics-platforms-and-.patch \
	file://0023-ci-add-STM32MP2x-platforms-default-build.patch \
	file://0024-plat-stm32mp1-default-disable-reserved-shared-memory.patch \
	file://0025-plat-stm32mp1-default-disable-CFG_STM32MP1_SCMI_SHM_.patch \
	file://0026-plat-stm32mp1-enable-async-notif-on-stm32mp13.patch \
	file://0027-core-arm-stmm_sp-fix-calls-to-tee_pobj_get.patch \
	file://0028-core-pta-attestation-fix-calls-to-tee_pobj_get.patch \
	file://0029-core-interrupt_raise_sgi-updates.patch \
	file://0030-core-interrupt-halt-other-cores-when-one-is-panickin.patch \
	file://0031-plat-stm32mp1-activate-CFG_CORE_HALT_CORES_ON_PANIC.patch \
	file://0032-plat-stm32mp2-activate-CFG_CORE_HALT_CORES_ON_PANIC.patch \
	file://0033-core-arm-check-for-NULL-mobj-before-thread_rpc_free.patch \
	file://0034-tree-wide-CFG_INSECURE-deprecates-CFG_WARN_INSECURE.patch \
	file://0035-plat-stm32mp1-CFG_INSECURE-y-allows-insecure-RCC-con.patch \
	file://0036-core-arm-fix-inline-comment-on-async-notif-interrupt.patch \
	file://0037-plat-stm32mp1-scmi_server-fix-regulator-framework-in.patch \
	file://0038-dts-stm32mp15-USBPHY-regulator-is-always-on-on-ST-bo.patch \
	file://0039-plat-stm32mp1-scmi_server-report-invalid-regulator-s.patch \
	file://0040-core-arm-allow-CFG_TZSRAM_START-being-defined-when-p.patch \
	file://0041-core-kernel-tee_ta_manager.c-add-uuid-in-open-sessio.patch \
	file://0042-drivers-regulator-GPIO-controlled-regulator.patch \
	file://0043-plat-stm32mp1-conf-enable-support-for-GPIO-regulator.patch \
	file://0044-plat-stm32mp1-conf-fix-order-for-CFG_REGULATOR_FIXED.patch \
	file://0045-core-tee_svc.c-allow-to-pass-non-NULL-memref-of-size.patch \
	file://0046-drivers-clk-print-clock-tree-summary.patch \
	file://0047-scmi-msg-fix-voltage-domains-inline-comment-header-f.patch \
	file://0048-core-dt_driver-don-t-enforce-phandle-1st-arg-is-a-ph.patch \
	file://0049-core-dt_driver-reference-output-device-reference-as-.patch \
	file://0050-core-interrupt-registering-interrupt-providers.patch \
	file://0051-core-interrupt-add-interrupt_create_handler.patch \
	file://0052-drivers-gic-register-to-dt_driver.patch \
	file://0053-drivers-gic-use-DT-bindings.patch \
	file://0054-core-MEM_AREA_ROM_SEC-maps-secure-read-only-cached-m.patch \
	file://0055-core-mm-use-MEM_AREA_END-to-detect-mapping-area-end.patch \
	file://0056-core-mmu-fix-nsec-ddr-discovery-regarding-MEM_AREA_R.patch \
	file://0057-plat-stm32mp1-syscfg-use-U-macro.patch \
	file://0058-plat-stm32mp1-syscfg-compute-base-address-once.patch \
	file://0059-plat-stm32mp1-syscfg-STM32MP13-dynamic-IO-compensati.patch \
	file://0060-plat-stm32mp1-syscfg-HLSV-mode-for-IO-domains.patch \
	file://0061-plat-stm32mp1-pwr-configure-HSLV-for-fixed-VDD-suppl.patch \
	file://0062-plat-stm32mp1-pwr-remove-test-on-CFG_DRIVERS_REGULAT.patch \
	file://0063-plat-stm32mp1-pwr-use-IO_READ32_POLL_TIMEOUT.patch \
	file://0064-drivers-regulator-IO-domain-regulators-for-STM32MP13.patch \
	file://0065-dts-stm32mp13-IO-domain-regulators.patch \
	file://0066-plat-stm32mp1-scmi_server-simplify-regulators-identi.patch \
	file://0067-plat-stm32mp1-scmi_server-expose-IOD-regulators.patch \
	file://0068-plat-stm32mp1-fix-warning-trace-on-TZC-configuration.patch \
	file://0069-drivers-regulator-fix-getting-GPIO-for-level-control.patch \
	file://0070-dts-stm32mp15-harden-RCC-secure-configuration-on-ST-.patch \
	file://0071-drivers-regulator-print-regulator-tree-summary.patch \
	file://0072-drivers-clk-change-queue-from-STAILQ-to-SLIST.patch \
	file://0073-drivers-clk-clk_print_tree-stub-for-disabled-CFG_DRI.patch \
	file://0074-drivers-clk-assert-registered-clock-pointer-is-not-N.patch \
	file://0075-drivers-clk-print-tree-without-recursion.patch \
	file://0076-drivers-clk-remove-spinlock-in-clk_print_tree.patch \
	file://0077-drivers-clk-print-clock-tree-with-debug-trace-level.patch \
	file://0078-core-fix-objectUsage-handling-for-persistent-objects.patch \
	file://0079-tree-wide-rename-struct-malloc_stats.patch \
	file://0080-core-rename-struct-tee_ta_dump_stats.patch \
	file://0081-pta-stats-initialize-local-variables-where-defined.patch \
	file://0082-pta-stats-export-PTA-API-definition-to-TA-devkit.patch \
	file://0083-tree-wide-clarify-PTA-ABI.patch \
	file://0084-pta-stats-rename-statistics-PTA.patch \
	file://0085-core-dt_driver-do-not-defer-probe-on-skip-phandler-a.patch \
	file://0086-core-add-interrupt_get_main_chip_may_fail.patch \
	file://0087-core-panic-avoid-panic-in-panic.patch \
	file://0088-drivers-regulator-fix-variable-sized-voltages-fallba.patch \
	file://0089-pta-stats-add-commands-to-print-clock-and-regulator-.patch \
	file://0090-drivers-regulator-stm32_vrefbuf-set-voltage-list-at-.patch \
	file://0091-plat-stm32mp1-set-voltage-list-at-pmic-driver-init.patch \
	file://0092-drivers-regulator-supported-voltage-consider-levels-.patch \
	file://0093-plat-stm32mp1-scmi_server-remove-useless-bounding-of.patch \
	file://0094-dts-stm32mp15-enable-secure-IWDG1-on-ST-boards.patch \
	file://0095-dts-stm32mp15-disable-non-secure-IWDG2-on-ST-boards.patch \
	file://0096-plat-stm32mp1-exposes-a-fastcall-SMC-watchdog-servic.patch \
	file://0097-core-mobj-initialize-earlier-generic-memory-object.patch \
	file://0098-core-sm-support-LPAE-in-monitor-context-backup.patch \
	file://0099-mk-config-allow-to-use-lightweight-tags-instead-of-a.patch \
	file://0100-plat-stm32mp1-conf-enable-the-WERROR-check.patch \
	file://0101-plat-stm32mp2-embed-some-extra-test-facilities.patch \
	file://0102-plat-stm32mp1-add-OEM-SMC-default-functions.patch \
	file://0103-plat-stm32mp1-get-DRAM-size-from-embedded-DTB.patch \
	file://0104-dt-bindings-add-YAML-documentation.patch \
	file://0105-plat-stm32mp1-do-not-generate-stm32-files.patch \
	file://0106-plat-stm32mp1-nsec-service-deprecate-scmi-agent-1.patch \
	file://0107-plat-stm32mp1-optimize-xlat-table-allocation.patch \
	file://0108-plat-stm32mp1-shared_resource-disable-MCKPROT-if-not.patch \
	file://0109-drivers-stm32_iwdg-fix-timeout-configuration.patch \
	file://0110-drivers-stm32_iwdg-provide-timeout-range.patch \
	file://0111-dts-stm32-populate-stm32mp251-SoC-device-tree-file.patch \
	file://0112-dts-stm32-add-stm32mp257f-dk-board-support.patch \
	file://0113-core-fix-trace-in-dt_driver-probe-sequence.patch \
	file://0114-core-dt-allow-using-_fdt_read_paddr-in-drivers.patch \
	file://0115-plat-stm32mp1-conf-increase-MMAP-regions-number.patch \
	file://0116-makefile-build-ta_dev_kit-but-not-TAs-when-CFG_WITH_.patch \
	file://0117-plat-stm32mp1-do-not-discriminate-how-CFG_TZDRAM_STA.patch \
	file://0118-plat-stm32mp1-add-CFG_STM32MP1_OPTEE_IN_SYSRAM.patch \
	file://0119-core-add-external-device-tree-support.patch \
	file://0120-plat-stm32mp2-add-external-device-tree-support.patch \
	file://0121-plat-stm32mp1-add-external-device-tree-support.patch \
	file://0122-plat-stm32mp1-conf-default-disable-CFG_EXTERNAL_DT-f.patch \
	file://0123-plat-stm32mp2-Add-stm32mp25-sysconfig-driver.patch \
	file://0124-pm-add-macro-for-PM_HINT_STATE-access.patch \
	file://0125-plat-stm32mp2-define-platform-PM-states.patch \
	file://0126-plat-stm32mp2-sysconfig-Handle-IO-compensation.patch \
	file://0127-plat-stm32mp2-sysconfig-add-OSPIs-address-mapping.patch \
	file://0128-plat-stm32mp2-sysconfig-add-Safe-Reset-functionality.patch \
	file://0129-plat-stm32mp2-add-VDERAM-SYSCFG-support.patch \
	file://0130-plat-stm32mp2-add-tamper-masking-in-SYSCFG-support.patch \
	file://0131-plat-stm32mp2-compile-drivers-subfolder.patch \
	file://0132-plat-stm32mp1-create-helper-file-for-stm32mp1.patch \
	file://0133-plat-stm32mp1-add-stm32_reset_system-function.patch \
	file://0134-plat-stm32mp1-rcc-header-can-be-included-in-assembly.patch \
	file://0135-drivers-clk-clk-stm32mp15-add-function-to-manage-MCU.patch \
	file://0136-drivers-clk-clk-stm32mp15-fix-typo-PMU-MPU.patch \
	file://0137-drivers-clk-clk-stm32mp15-add-stm32mp_rcc_clk_to_clo.patch \
	file://0138-drivers-clk-stm32mp15-fix-incorrect-pll-dt-parsing.patch \
	file://0139-drivers-clk-stm32mp15-force-clk_op_compute_rate-in-u.patch \
	file://0140-plat-stm32mp1-enable-fixed-clock-in-stm32mp15.patch \
	file://0141-drivers-clk-add-clock-PM-callback-in-clk-stm32mp15.c.patch \
	file://0142-dt-bindings-stm32-add-stm32mp1-clksrc.h-bindings.patch \
	file://0143-dts-stm32mp15-describe-clock-tree-configuration.patch \
	file://0144-drivers-clk-clk_stm32_parse_fdt_by_name-can-error.patch \
	file://0145-drivers-clk-stm32mp15-apply-full-clock-tree-in-OP-TE.patch \
	file://0146-drivers-clk-stm32mp15-add-the-operating-point-suppor.patch \
	file://0147-dt-bindings-stm32-fix-CLKSRC-for-RTC-in-stm32mp13-cl.patch \
	file://0148-clk-stm32mp13-removal-of-LSE-clock-on-RNG-clock-swit.patch \
	file://0149-clk-stm32mp13-do-not-reconfigure-LSE.patch \
	file://0150-clk-stm32mp13-round-up-to-the-nearest-frequency-the-.patch \
	file://0151-clk-stm32mp13-add-adc-bus-clocks.patch \
	file://0152-clk-stm32mp13-fix-bad-copy-paste-on-gate-assignment.patch \
	file://0153-clk-stm32mp13-cosmetic-remove-useless-space.patch \
	file://0154-clk-stm32mp13-SPIx-clocks-are-missing.patch \
	file://0155-clk-stm32mp13-check-sprintf-return-value.patch \
	file://0156-clk-stm32mp13-fix-of-CKPER-clock-disabling.patch \
	file://0157-clk-stm32mp13-remove-the-iwdg1-from-the-critical-clo.patch \
	file://0158-clk-stm32-core-set-clock-number-to-0-if-node-is-not-.patch \
	file://0159-clk-fix-bad-clock-rate.patch \
	file://0160-clk-add-is_enabled-ops.patch \
	file://0161-clk-stm32mp13-implement-is_enabled-clock-ops.patch \
	file://0162-clk-add-CLK_OPS_PARENT_ENABLE-flags.patch \
	file://0163-clk-add-CLK_SET_RATE_PARENT-flags.patch \
	file://0164-clk-stm32mp13-add-CLK_SET_RATE_PARENT-CLK_OPS_PARENT.patch \
	file://0165-clk-stm32mp13-fix-stm32mp13_clk_probe-3498-Failed-to.patch \
	file://0166-drivers-clk-implement-clk_get_rates_steps.patch \
	file://0167-clk-add-determine-rate-ops.patch \
	file://0168-clk-add-CLK_SET_RATE_UNGATE-flag-management.patch \
	file://0169-clk-add-duty-cycle-ops.patch \
	file://0170-clk-add-round-rate-ops.patch \
	file://0171-drivers-clk-add-functions-to-save-restore-clock-cont.patch \
	file://0172-drivers-clk-export-clk_get_parent_idx.patch \
	file://0173-clk-stm32mp13-don-t-gate-ungate-an-oscillator-if-it-.patch \
	file://0174-clk-stm32mp13-implement-multi-gate-management.patch \
	file://0175-clk-stm32mp13-add-duty-cycle-for-pll-dividers.patch \
	file://0176-clk-stm32mp13-add-round-rate.patch \
	file://0177-clk-stm32mp13-use-determine_rate-for-OPP.patch \
	file://0178-clk-stm32mp13-add-power-management.patch \
	file://0179-clk-stm32mp-add-support-of-pinctrl-and-clock-for-RCC.patch \
	file://0180-dts-stm32-enable-stm32-rcc-driver-for-stm32mp135f-dk.patch \
	file://0181-plat-stm32mp2-add-rcc-helper-function.patch \
	file://0182-dt-bindings-add-the-STM32MP2-clock-and-reset-binding.patch \
	file://0183-clk-stm32mp25-introduction-mp25-clock.patch \
	file://0184-drivers-stm32_rstctrl-move-stm32mp1x-controller-in-s.patch \
	file://0185-drivers-rstctrl-Add-reset-controller-for-STM32MP25-p.patch \
	file://0186-clk-stm32mp25-enable-Safe-Reset-functionality.patch \
	file://0187-clk-stm32mp25-implement-is_enabled-clock-ops.patch \
	file://0188-clk-stm32mp25-add-CLK_SET_RATE_PARENT-flag-for-LTDC-.patch \
	file://0189-clk-stm32mp25-add-CLK_SET_RATE_UNGATE-flag-to-Flexge.patch \
	file://0190-clk-stm32mp25-add-round-rate-for-flexgen.patch \
	file://0191-clk-add-clk_reparent-function.patch \
	file://0192-clk-stm32mp25-PLL3-parent-clock-was-not-updated.patch \
	file://0193-clk-stm32mp25-introduce-OPP-management-for-CPU1.patch \
	file://0194-clk-stm32mp25-add-clock-observer-functionality.patch \
	file://0195-clk-stm32mp25-add-support-of-pinctrl-and-clock-for-R.patch \
	file://0196-dts-st-enable-RCC-driver-in-stm32mp251.patch \
	file://0197-drivers-stm32_gpio-Fix-coding-style-issues-for-gpio.patch \
	file://0198-drivers-stm32_gpio-add-secure-configuration-for-GPIO.patch \
	file://0199-dt-bindings-add-TZPROT-macro.patch \
	file://0200-dts-stm32-secure-pins-for-secure-peripherals-on-stm3.patch \
	file://0201-drivers-stm32_gpio-add-power-management.patch \
	file://0202-drivers-stm32_gpio-add-support-for-stm32mp25.patch \
	file://0203-plat-stm32mp1-use-unsigned-values-for-TZC400-identif.patch \
	file://0204-plat-stm32mp1-plat_tzc400-local-function-to-check-DD.patch \
	file://0205-plat-stm32mp1-plat_tzc400-move-driver-to-dt_driver.patch \
	file://0206-plat-stm32mp1-plat_tzc400-get-interrupt-from-DT-node.patch \
	file://0207-plat-stm32mp1-plat-tzc400-flexible-check-of-firewall.patch \
	file://0208-core-dt-bindings-add-stm32mp-tzc400-bindings.patch \
	file://0209-plat-stm32mp1-tzc400-use-the-device-tree-configurati.patch \
	file://0210-plat-stm32mp1-tzc400-add-pm-callback-function.patch \
	file://0211-dts-stm32-add-the-tzc400-node-for-stm32mp15-platform.patch \
	file://0212-dts-stm32-populate-UART-nodes-in-stm32mp251-SoC-devi.patch \
	file://0213-dts-stm32-add-stm32mp25-UART-console-pins.patch \
	file://0214-dts-stm32-enable-USART2-node-on-stm32mp257f-ev1-boar.patch \
	file://0215-dts-stm32-enable-USART2-node-on-stm32mp257f-dk-board.patch \
	file://0216-dts-stm32-add-support-for-a-variety-of-stm32mp15-boa.patch \
	file://0217-plat-stm32mp1-define-platform-flavors-per-DTS-file.patch \
	file://0218-plat-stm32mp1-add-Makefile-target-to-build-all-DTB-f.patch \
	file://0219-core-plat-stm32mp1-properly-encapsulate-pager-code-w.patch \
	file://0220-drivers-clk_dt-include-missing-clk.h-header-file.patch \
	file://0221-core-dt-export-add_probe_node_by_compat-function.patch \
	file://0222-drivers-stm32_firewall-add-a-firewall-interface.patch \
	file://0223-dt-bindings-add-platform-specific-ETZPC-bindings.patch \
	file://0224-plat-stm32mp1-conf-force-using-firewall-framework.patch \
	file://0225-dts-stm32-define-etzpc-as-stm32mp15-firewall-bus-con.patch \
	file://0226-dts-stm32-add-the-etzpc-configuration-table-for-boar.patch \
	file://0227-dts-stm32-use-non-secure-I2C-compatible-on-MP15-boar.patch \
	file://0228-drivers-firewall-probe-exception-for-i2c4.patch \
	file://0229-drivers-stm32_etzpc-new-driver-to-use-firewall-API.patch \
	file://0230-plat-stm32mp1-update-to-use-firewall-API.patch \
	file://0231-drivers-stm32_etzpc-remove-unused-code.patch \
	file://0232-plat-stm32mp1-add-base-address-into-reset-structure.patch \
	file://0233-dts-stm32-add-cryp1-as-an-ETZPC-subnode.patch \
	file://0234-stm32mp2-add-RIF-dt-binding-defines.patch \
	file://0235-dt-bindings-add-RIF-to-default-bindings-config-for-s.patch \
	file://0236-drivers-firewall-add-stm32_rif-driver-for-common-RIF.patch \
	file://0237-plat-stm32mp2-conf-support-RIF-driver.patch \
	file://0238-drivers-stm32_rif-support-lock-of-the-RIF-configurat.patch \
	file://0239-drivers-stm32_rif-stub-functions-when-CFG_STM32_RIF-.patch \
	file://0240-drivers-stm32_firewall-add-new-APIs-for-IOM.patch \
	file://0241-dt-bindings-add-RIFSC-dt-binding-defines.patch \
	file://0242-drivers-add-stm32-RIFSC-support.patch \
	file://0243-drivers-stm32_rifsc-add-firewall-framework.patch \
	file://0244-plat-stm32mp2-conf-enable-RIFSC-driver.patch \
	file://0245-dt-bindings-add-RIFSC-to-default-bindings-config-for.patch \
	file://0246-drivers-stm32_rifsc-add-execution-context-TDCID-chec.patch \
	file://0247-drivers-stm32_rifsc-add-lock-capabilities-for-the-RI.patch \
	file://0248-drivers-stm32_rifsc-add-semaphore-acquisition.patch \
	file://0249-drivers-stm32_rifsc-add-semaphore-handling-in-low-po.patch \
	file://0250-stm32mp2-add-RISAF-device-tree-bindings.patch \
	file://0251-dt-bindings-add-RISAF-to-default-bindings-config-for.patch \
	file://0252-core-drivers-add-RISAF-driver.patch \
	file://0253-plat-stm32mp2-default-enable-RISAF-driver.patch \
	file://0254-drivers-stm32_risaf-add-a-reconfigure-function.patch \
	file://0255-drivers-stm32_risaf-enforce-encryption-control-on-co.patch \
	file://0256-drivers-stm32_risaf-add-RISAF-faulty-address-dumping.patch \
	file://0257-drivers-stm32_risaf-skip-op_tee-region-configuration.patch \
	file://0258-drivers-stm32_risaf-add-instance-granularity-to-driv.patch \
	file://0259-drivers-stm32_risaf-add-region-overlap-check.patch \
	file://0260-drivers-stm32_risaf-add-power-management-sequence.patch \
	file://0261-dt-bindings-introduce-RISAB-device-tree-bindings.patch \
	file://0262-drivers-stm32_risab-support-RISAB-driver.patch \
	file://0263-plat-stm32mp2-conf-support-RISAB-driver.patch \
	file://0264-dt-bindings-add-RISAB-to-default-bindings-config-for.patch \
	file://0265-drivers-stm32_risab-add-RISAB-faulty-address-dumping.patch \
	file://0266-drivers-stm32_risab-add-power-management-sequence.patch \
	file://0267-drivers-stm32_risab-adds-VDERAM-s-RISAB-specificitie.patch \
	file://0268-dts-stm32-add-stm32mp257f-ev1-board-configuration-su.patch \
	file://0269-drivers-stm32_iwdg-remove-stm32_iwdg_refresh.patch \
	file://0270-drivers-stm32_iwdg-rename-bus-clock-to-clk_pclk.patch \
	file://0271-drivers-stm32_iwdg-enable-bus-clock-once-for-all.patch \
	file://0272-drivers-stm32_iwdg-enable-state-helper-functions.patch \
	file://0273-drivers-stm32_iwdg-probe-if-watchdog-is-running.patch \
	file://0274-drivers-stm32_iwdg-remove-OTP-access-in-driver.patch \
	file://0275-drivers-stm32_iwdg-early-watchdog-interrupt.patch \
	file://0276-drivers-stm32_iwdg-disable-clocks-during-PM-standby.patch \
	file://0277-drivers-wdt-add-implementation-of-SMCWD_GET_TIMELEFT.patch \
	file://0278-drivers-stm32_iwdg-add-get_timeleft-watchdog-handler.patch \
	file://0279-drivers-gic-register-pm-callbacks.patch \
	file://0280-drivers-gic-restore-GIC-main-config-at-resume.patch \
	file://0281-drivers-gic-API-for-PMR-and-priority-configuration.patch \
	file://0282-drivers-gic-use-GIC_HIGHEST_NS_PRIORITY-macro.patch \
	file://0283-drivers-gic-fix-local-variables-definition.patch \
	file://0284-plat-stm32mp1-enable-CFG_ARM_GIC_PM-in-conf.mk.patch \
	file://0285-plat-stm32mp1-stm32mp1_pwr-battery-charge.patch \
	file://0286-plat-stm32mp1-SiP-SMC-service-for-PWR-access.patch \
	file://0287-dt-bindings-soc-add-some-RIF-aware-peripheral-IDs.patch \
	file://0288-drivers-firewall-add-stm32-iac-support.patch \
	file://0289-drivers-stm32_rif-add-stm32_rif_access_violation_act.patch \
	file://0290-drivers-stm32_iac-add-CFG_STM32_PANIC_ON_IAC_EVENT-s.patch \
	file://0291-plat-stm32mp2-conf-activate-iac-support.patch \
	file://0292-dts-stm32-enable-IAC-support-on-stm32mp2.patch \
	file://0293-drivers-firewall-add-stm32-serc-support.patch \
	file://0294-drivers-firewall-add-stm32-serc-power-sequence.patch \
	file://0295-drivers-stm32_serc-add-CFG_STM32_PANIC_ON_SERC_EVENT.patch \
	file://0296-plat-stm32mp2-conf-activate-serc-support.patch \
	file://0297-dts-stm32-enable-SERC-support-on-stm32mp25x-platform.patch \
	file://0298-core-add-platform-specific-abort-handler.patch \
	file://0299-plat-stm32mp2-add-platform-specific-abort-handler.patch \
	file://0300-plat-stm32mp2-conf-add-stm32mp257f-dk-board-support.patch \
	file://0301-dts-stm32-populate-RISAF-nodes.patch \
	file://0302-dts-stm32-enable-risaf2-5-nodes-for-stm32mp257f-ev1.patch \
	file://0303-dts-stm32-enable-risaf2-5-nodes-for-stm32mp257f-dk.patch \
	file://0304-dts-stm32-populate-RISAB-nodes.patch \
	file://0305-dts-stm32-add-RIFSC-compatible-to-enable-it.patch \
	file://0306-plat-stm32mp1-add-global-defines-in-platform_config..patch \
	file://0307-plat-stm32mp1-chip-and-platform-identification.patch \
	file://0308-plat-stm32mp1-retrieve-chip-id-from-syscfg-for-STM32.patch \
	file://0309-plat-stm32mp1-add-new-API-to-erase-SRAM3.patch \
	file://0310-plat-stm32mp1-conf-introduce-CFG_SYSCFG-switch.patch \
	file://0311-drivers-stm32_rtc-introduce-STM32-RTC-driver.patch \
	file://0312-drivers-stm32_rtc-add-stm32mp25-and-RIF-support-for-.patch \
	file://0313-drivers-stm32_rtc-add-stm32_rtc_driver_is_initialize.patch \
	file://0314-plat-stm32mp1-conf-enable-the-RTC-driver.patch \
	file://0315-plat-stm32mp2-conf-support-RTC-driver.patch \
	file://0316-plat-stm32mp1-move-the-initialisation-function-in-th.patch \
	file://0317-drivers-stm32_bsec3-add-BSEC-driver-support.patch \
	file://0318-plat-stm32mp2-add-platform-resources-for-BSEC3.patch \
	file://0319-plat-stm32mp2-conf-support-BSEC3-driver.patch \
	file://0320-ta-stm32mp_nvmem-add-provisioning-TA-for-OTP-purpose.patch \
	file://0321-plat-stm32mp1-enable-stm32mp_nvmem-early-TA.patch \
	file://0322-plat-stm32mp2-conf-add-the-PTA-NVMEM.patch \
	file://0323-dt-bindings-add-binding-for-the-stm32mp-provisioning.patch \
	file://0324-drivers-stm32mp_provisioning-add-driver-to-manage-sh.patch \
	file://0325-plat-stm32mp2-conf-enable-the-provisioning-driver.patch \
	file://0326-dts-stm32-add-bsec-node-in-stm32mp251.dtsi.patch \
	file://0327-dts-stm32-add-default-HCONF1-value-for-VDDIO-on-stm3.patch \
	file://0328-dts-stm32-add-default-HCONF1-value-for-VDDIO-on-stm3.patch \
	file://0329-drivers-stm32_stgen-add-STGEN-support.patch \
	file://0330-drivers-stm32_stgen-support-low-power-sequence.patch \
	file://0331-plat-stm32mp2-conf-default-enable-STGEN-for-STM32MP2.patch \
	file://0332-dts-stm32-populate-the-STGEN-node-in-stm32mp251.dtsi.patch \
	file://0333-drivers-stm32_exti-add-stm32mp_exti.patch \
	file://0334-plat-stm32mp1-conf-enable-EXTI-driver-for-STM32MP13.patch \
	file://0335-plat-stm32mp2-conf-enable-EXTI-for-stm32mp2-platform.patch \
	file://0336-drivers-stm32_exti-add-generic-compatible-st-stm32mp.patch \
	file://0337-drivers-stm32_exti-stm32mp_exti-drop-compile-macro-C.patch \
	file://0338-drivers-stm32_exti-register-the-driver-as-provider.patch \
	file://0339-drivers-stm32_exti-stm32mp_exti-align-extern-prototy.patch \
	file://0340-drivers-stm32_exti-move-PM-backup-storage-in-private.patch \
	file://0341-drivers-stm32_exti-remove-r-w-data-from-struct-stm32.patch \
	file://0342-drivers-stm32_exti-remove-struct-stm32_exti_bank.patch \
	file://0343-drivers-stm32_exti-move-lock-in-private-data.patch \
	file://0344-drivers-stm32_exti-add-parameter-for-exti-instance.patch \
	file://0345-drivers-stm32_exti-let-exported-function-use-private.patch \
	file://0346-drivers-stm32_exti-add-multi-instance-support.patch \
	file://0347-drivers-stm32_exti-add-RIF-support-for-EXTI.patch \
	file://0348-drivers-stm32_exti-support-lock-of-the-RIF-configura.patch \
	file://0349-dts-stm32-add-EXTI-node-in-stm32mp131.patch \
	file://0350-dts-stm32-align-the-EXTI-nodes-to-kernel-DT-in-stm32.patch \
	file://0351-drivers-sm32_tamp-upgrade-stm32_tamp-driver.patch \
	file://0352-drivers-stm32_tamp-add-stm32mp25-and-RIF-support-for.patch \
	file://0353-drivers-stm32_tamp-add-backup-registers-RIF-configur.patch \
	file://0354-drivers-stm32_tamp-allow-subnode-to-be-probed.patch \
	file://0355-drivers-stm32_tamp-use-clk_enable-error-code.patch \
	file://0356-drivers-stm32_tamp-migrate-tamper-configuration-in-t.patch \
	file://0357-drivers-stm32_tamp-add-STM32MP25x-platforms-tampers-.patch \
	file://0358-drivers-stm32_tamp-add-support-for-masking-potential.patch \
	file://0359-dts-stm32-fix-RTC-node-at-STM32MP1-SoC-level.patch \
	file://0360-dts-stm32-add-support-for-RTC-on-stm32mp251.dtsi.patch \
	file://0361-dts-stm32-enable-RTC-on-stm32mp257f-ev1.patch \
	file://0362-dts-stm32-enable-RTC-on-stm32mp257f-dk.patch \
	file://0363-dt-bindings-stm32_tamp-add-tamper-bindings.patch \
	file://0364-dts-stm32-activate-tamper-node-for-STM32MP257F-EV1-b.patch \
	file://0365-dts-stm32-activate-tamper-node-for-STM32MP257F-DK-bo.patch \
	file://0366-dts-stm32-add-STM32MP13-tamper-pinctrl-nodes.patch \
	file://0367-dts-stm32-add-tamper-configuration-on-stm32mp135f-dk.patch \
	file://0368-dts-stm32-add-tamper-configuration-on-stm32mp15x-dis.patch \
	file://0369-dts-stm32-populate-TAMP-node-in-stm32mp251.dtsi.patch \
	file://0370-plat-stm32mp2-conf-support-TAMP-driver.patch \
	file://0371-dts-stm32-fix-TAMP-node-on-stm32mp131.dtsi.patch \
	file://0372-dts-stm32-enable-rtc-on-stm32mp157c-exx.patch \
	file://0373-drivers-stm32mp25-new-FMC-driver-with-RIF-support.patch \
	file://0374-plat-stm32mp2-conf-support-FMC-driver.patch \
	file://0375-drivers-stm32mp_provisioning-support-low-power-seque.patch \
	file://0376-drivers-stm32mp_provisioning-fix-content-of-trace.patch \
	file://0377-drivers-stm32mp_provisioning-fix-error-when-no-subno.patch \
	file://0378-plat-stm32mp2-configure-SRAM1-as-shadow-location.patch \
	file://0379-drivers-stm32_omm-add-OSPI-Memory-Manager-driver.patch \
	file://0380-plat-stm32mp2-conf-enable-OMM-driver.patch \
	file://0381-dts-stm32-add-ommanager-node-in-stm32mp251.dtsi.patch \
	file://0382-dts-stm32-add-IOM-EVAL-pins-muxing-configurations-fo.patch \
	file://0383-dts-stm32-enable-OSPI1-for-stm32mp257f-ev1-board.patch \
	file://0384-dts-stm32-add-FMC-support-on-stm32mp2.patch \
	file://0385-rebase-tamp-dts-stm32-add-TAMP-interrupt-line-for-ST.patch \
	file://0386-drivers-stm32_rng-check-clock-enable-call.patch \
	file://0387-drivers-stm32_rng-remove-__unused-attribute.patch \
	file://0388-drivers-stm32_rng-add-debug-traces-for-test-purpose.patch \
	file://0389-drivers-stm32_rng-add-RNG_NIST_CONFIG_C-custom-confi.patch \
	file://0390-drivers-stm32_rng-add-support-for-device-tree-RNG-co.patch \
	file://0391-drivers-stm32_rng-add-health-test-and-noise-source-c.patch \
	file://0392-drivers-stm32_rng-allow-RNG-configurations-to-be-def.patch \
	file://0393-drivers-stm32_rng-fix-RNG-initialization.patch \
	file://0394-drivers-stm32_rng-fix-comment-in-stm32_rng_pm_resume.patch \
	file://0395-drivers-stm32_rng-add-support-for-RNG-power-optimisa.patch \
	file://0396-drivers-stm32_rng-ensure-conditional-reset-sequence-.patch \
	file://0397-drivers-stm32_rng-print-RNG-version-at-driver-probe-.patch \
	file://0398-drivers-stm32_rng-put-max-noise-freq-in-compat-data.patch \
	file://0399-drivers-stm32_rng-implement-clock-support-for-STM32M.patch \
	file://0400-drivers-stm32_rng-move-RNG-configuration-to-compat-d.patch \
	file://0401-drivers-stm32_rng-fix-secure-hardware-RNG-when-using.patch \
	file://0402-drivers-stm32_rng-factorize-clock-gating-instruction.patch \
	file://0403-drivers-stm32_rng-export-init-and-read-functions.patch \
	file://0404-plat-stm32mp2-conf-default-enable-RNG-and-RNG-PTA.patch \
	file://0405-dts-stm32-populate-RNG-node-in-stm32mp251.dtsi.patch \
	file://0406-drivers-stm32mp25-new-HPDMA-driver-with-RIF-support.patch \
	file://0407-plat-stm32mp2-conf-support-HPDMA-driver.patch \
	file://0408-dts-add-support-for-HPDMA.patch \
	file://0409-core-drivers-add-RIF-support-for-HSEM.patch \
	file://0410-plat-stm32mp2-conf-support-HSEM-driver.patch \
	file://0411-dts-stm32-update-HSEM-node-in-stm32mp251.dtsi.patch \
	file://0412-drivers-stm32_ipcc-add-RIF-support-for-IPCC.patch \
	file://0413-plat-stm32mp2-conf-support-IPCC-driver.patch \
	file://0414-dts-stm32-update-IPCC1-2-nodes-in-stm32mp251.dtsi.patch \
	file://0415-dts-stm32mp25-add-watchdog-support-on-stm32mp2.patch \
	file://0416-core-arm-kernel_spmc-correct-CFG_SECURE_PARTITION-te.patch \
	file://0417-core-arm-get-DDR-range-from-embedded-DTB.patch \
	file://0418-core-mm-print-non-secure-memory-ranges.patch \
	file://0419-plat-stm32mp2-allow-up-to-8GB-of-external-RAM.patch \
	file://0420-plat-stm32mp2-panic-of-TZC-interrupt.patch \
	file://0421-drivers-i2c-add-missing-__unused-in-stubbed-function.patch \
	file://0422-drivers-stm32_i2c-apply-pinctrl-config-at-init.patch \
	file://0423-drivers-stm32_i2c-fix-calls-to-stm32_pinctrl_set_sec.patch \
	file://0424-drivers-stm32_i2c-fix-header-file-inclusion-order.patch \
	file://0425-plat-stm32mp2-enable-watchdog-SMC-service.patch \
	file://0426-dts-stm32-enable-IWDG1-on-stm32mp25-boards.patch \
	file://0427-plat-stm32mp2-conf-default-enable-CFG_STM32_IWDG.patch \
	file://0428-plat-stm32mp2-Enable-regulator-support.patch \
	file://0429-plat-stm32mp2-Default-enable-CFG_DRIVERS_CLOCK_PRINT.patch \
	file://0430-drivers-regulator-DT-properties-active-discharge-ove.patch \
	file://0431-drivers-regulator-DT-property-regulator-ramp-delay.patch \
	file://0432-drivers-regulator-DT-property-regulator-enable-ramp-.patch \
	file://0433-plat-stm32mp2-Add-PWR-driver.patch \
	file://0434-plat-stm32mp2-Add-PWR-regulators-driver.patch \
	file://0435-plat-stm32mp2-introduce-stpmic2-driver.patch \
	file://0436-dts-stm32-Configure-STPMIC2-in-i2C7-for-stm32mp257f-.patch \
	file://0437-drivers-scmi-msg-implement-duty-cycle-ops-with-SCMI-.patch \
	file://0438-plat-stm32mp1-scmi-clock-duty-cycle.patch \
	file://0439-drivers-scmi-msg-round-rate.patch \
	file://0440-plat-stm32mp1-scmi-fix-supported-clock-rate.patch \
	file://0441-pta-scmi-ocall2-threaded-context.patch \
	file://0442-pta-scmi-support-Ocall2-on-MSG-channel.patch \
	file://0443-pta-scmi-support-OCall-with-SCP-firmware.patch \
	file://0444-pta-scmi-remove-noisy-info-level-message-on-message-.patch \
	file://0445-drivers-scmi_msg-fix-size_t-trace-format.patch \
	file://0446-drivers-scmi-msg-introduce-SCMI-regulator-consumer.patch \
	file://0447-dts-stm32mp13-Define-scmi-regulator-consumers.patch \
	file://0448-dts-stm32mp25-Define-scmi-regulator-consumer.patch \
	file://0449-plat-stm32mp1-scmi_server-support-SCMI-regulator-con.patch \
	file://0450-core-scmi_server-fix-alphabetical-order.patch \
	file://0451-core-scmi-server-implement-SCMI-regulator-consumers.patch \
	file://0452-core-scmi-server-Move-to-optee-voltd-regulator-modul.patch \
	file://0453-scpfw-module-optee-Add-voltage-domain-regulators.patch \
	file://0454-scpfw-module-optee-voltd_regulator-Upgrade-voltage-l.patch \
	file://0455-scpfw-module-wide-scmi-clock-upgrade-on-specificatio.patch \
	file://0456-scpfw-module-clock-remove-const-containts-in-module-.patch \
	file://0457-scpfw-module-voltage_domain-remove-const-attribute-f.patch \
	file://0458-scpfw-module-optee-clock-get-rates-in-continous-desc.patch \
	file://0459-scpfw-module-wide-scmi-clock-duty-cycle-support.patch \
	file://0460-scpfw-module-wide-scmi-clock-round-rate-support.patch \
	file://0461-scpfw-product-optee-stm32mp2-psu-back-end-module-for.patch \
	file://0462-scpfw-product-optee-stm32mp2-expose-STM32MP25-SCMI-r.patch \
	file://0463-scpfw-module-scmi_clock-64bit-clock-rate-computation.patch \
	file://0464-scpfw-product-optee-stm32mp1-psu-back-end-module-for.patch \
	file://0465-scpfw-product-optee-stm32mp1-update-STM32MP15-STM32M.patch \
	file://0466-scpfw-arch-none-optee-Define-OP-TEE-passed-CMake-con.patch \
	file://0467-scpfw-module-optee-clock-fix-device-error-cases.patch \
	file://0468-scpfw-product-optee-stm32mp2-update-psu-back-end-mod.patch \
	file://0469-scpfw-product-optee-stm32mp-set-initial-DVFS-OPP-sta.patch \
	file://0470-core-scmi-server-build-in-tree-SCP-firmware-source-f.patch \
	file://0471-core-scmi-server-set-CFG_SCPFW_MOD_-CMake-build-dire.patch \
	file://0472-plat-stm32mp-conf-sync-with-SCP-firmware-v2.13-dev-b.patch \
	file://0473-clk-stm32mp25-add-RIF-support-for-RCC.patch \
	file://0474-clk-stm32mp25-add-low-power-support-for-RIF-configur.patch \
	file://0475-clk-stm32-core-remove-static-for-stm32_gate-and-stm3.patch \
	file://0476-clk-stm32mp25-check-RIF-access-for-root-clocks.patch \
	file://0477-clk-stm32mp25-restore-oscillator-clocks-after-a-stan.patch \
	file://0478-clk-stm32mp25-restore-plls-4-to-8-after-a-standby.patch \
	file://0479-clk-stm32mp25-restore-flexgen-clocks-after-a-standby.patch \
	file://0480-clk-stm32mp25-restore-share-clocks-after-a-standby.patch \
	file://0481-clk-stm32mp25-restore-RCC-driver-after-a-standby.patch \
	file://0482-driver-clk-rcc-restore-clock-for-standby.patch \
	file://0483-clk-stm32mp25-set-ck_icn_p_gicv2m-as-critical.patch \
	file://0484-clk-stm32mp25-add-clock-frequency-calculation-functi.patch \
	file://0485-clk-stm32mp25-put-BKPSRAM-clock-as-critical.patch \
	file://0486-clk-stm32mp25-put-all-fexgen-clocks-as-critical.patch \
	file://0487-core-kernel-trace_ext-add-printf-function.patch \
	file://0488-clk-stm32mp13-debug-add-display-of-all-DT-config-of-.patch \
	file://0489-clk-stm32mp15-debug-add-display-of-all-DT-config-of-.patch \
	file://0490-clk-stm32mp25-debug-add-display-of-all-DT-config-of-.patch \
	file://0491-plat-stm32mp1-default-enable-CFG_DRIVERS_-_PRINT_TRE.patch \
	file://0492-dts-stm32-sync-stm32mp15-with-3.19.0-stm32mp-dev.patch \
	file://0493-dts-stm32-sync-stm32mp25-with-3.19.0-stm32mp-dev.patch \
	file://0494-plat-stm32mp1-scmi-server-may-not-embed-voltage-doma.patch \
	file://0495-plat-stm32mp1-default-disable-SCMI-voltage-domains-o.patch \
	file://0496-dts-stm32-fix-PI8-RIF-configuration-on-STM32MP25-DK-.patch \
	file://0497-dts-stm32-secure-the-tamper-button-pin.patch \
	file://0498-drivers-firewall-add-probe-exception-for-LTDC.patch \
	file://0499-core-drivers-add-RIF-support-for-GPIOS.patch \
	file://0500-plat-stm32mp2-Add-all_dtbs-build-target.patch \
	file://0501-plat-stm32mp2-conf-support-WRITE-in-BSEC-driver.patch \
	file://0502-drivers-stm32mp15_huk-fix-type-mismatch-in-stm32mp15.patch \
	file://0503-drivers-regulator-read-current-level-from-the-device.patch \
	file://0504-plat-stm32mp2-open-the-complete-debug-access-on-STM3.patch \
	file://0505-drivers-stm32_rng-keep-random-generation-on-when-opt.patch \
	file://0506-core-dt_driver-add-DT_DRIVER_NVMEM-support.patch \
	file://0507-drivers-nvmem-add-API-for-nvmem-controllers.patch \
	file://0508-drivers-nvmem-add-write-API-for-nvmem-controllers.patch \
	file://0509-dts-stm32-add-nvram-NVMEM-node-under-tamp-in-stm32mp.patch \
	file://0510-dts-stm32-declare-the-reboot-modes-in-stm32mp131.dts.patch \
	file://0511-dts-stm32-add-nvram-NVMEM-node-under-tamp-in-stm32mp.patch \
	file://0512-dts-stm32-add-reboot-mode-in-stm32mp151.dtsi.patch \
	file://0513-dts-stm32-add-nvram-NVMEM-node-under-tamp-in-stm32mp.patch \
	file://0514-dts-stm32-declare-the-reboot-modes-in-stm32mp251.dts.patch \
	file://0515-drivers-nvmem-stm32_tamp_nvram-add-TAMP-Backup-regis.patch \
	file://0516-plat-stm32mp1-enable-nvmem-support-for-TAMP-Backup-r.patch \
	file://0517-drivers-clk-fix-RCC-pinctrl.patch \
	file://0518-dts-stm32-add-the-optee-framebuffer-memory-region-in.patch \
	file://0519-plat-stm32mp1-BKPRAM-driver-support.patch \
	file://0520-plat-stm32mp1-implement-stm32mp_stgen_base.patch \
	file://0521-plat-stm32mp1-DDR-driver-for-low-power-sequence.patch \
	file://0522-plat-stm32mp1-update-boot_api-to-include-new-magic-n.patch \
	file://0523-dt-bindings-add-PWR-dt-bindings.patch \
	file://0524-drivers-include-add-power-define-in-stm32mp_dt_bindi.patch \
	file://0525-plat-stm32mp1-psci-use-the-stm32_system_reset.patch \
	file://0526-plat-stm32mp1-add-low-power-drivers-for-stm32mp1.patch \
	file://0527-plat-stm32mp1-scmi-add-the-power-management-in-serve.patch \
	file://0528-plat-stm32mp1-SiP-SMC-services-for-low-power.patch \
	file://0529-plat-stm32mp1-update-PSCI-ops-to-define-the-PSCI-sus.patch \
	file://0530-plat-stm32mp1-conf-enable-power-management-on-stm32m.patch \
	file://0531-plat-stm32mp1-map-DDR-bottom-page-for-STM32MP13-as-w.patch \
	file://0532-dts-stm32-Add-low-power-modes-description-for-stm32m.patch \
	file://0533-dts-stm32mp15-add-low-power-modes-and-regulator-leve.patch \
	file://0534-plat-stm32mp1-scmi-fix-assert-after-low-power.patch \
	file://0535-plat-stm32mp1-stm32mp1_pmic-add-LPLV_STOP2-mode.patch \
	file://0536-libutee-add-new-remoteproc-PTA-API.patch \
	file://0537-drivers-add-stm32mp1-remoteproc-driver.patch \
	file://0538-pta-stm32mp-add-new-remoteproc-PTA.patch \
	file://0539-pta-stm32mp-fix-remoteproc-config-name.patch \
	file://0540-plat-stm32mp1-Add-the-remoteproc-TA-in-early-TA-list.patch \
	file://0541-libutee-add-TEE_U-_FROM-TO_LITTLE_ENDIAN.patch \
	file://0542-ta-remoteproc-add-firmware-ELF-parser.patch \
	file://0543-ta-remoteproc-add-remote-processor-Trusted-Applicati.patch \
	file://0544-ta-remoteproc-add-support-for-start-and-stop-command.patch \
	file://0545-ta-remoteproc-add-support-for-resource-table.patch \
	file://0546-drivers-stm32_remoteproc-add-support-of-the-stm32mp2.patch \
	file://0547-plat-stm32mp2-add-remoteproc-firmware-loading-suppor.patch \
	file://0548-drivers-stm32_remoteproc-handle-temporary-st-s_memor.patch \
	file://0549-drivers-stm32_remoteproc-add-possibility-to-set-the-.patch \
	file://0550-pta-stm32mp-remoteproc-implement-the-PTA_REMOTEPROC_.patch \
	file://0551-ta-remoteproc-add-the-platform-TLV-support.patch \
	file://0552-scripts-sign_rproc_fw-add-BOOTADDR-and-BOOTSEC-platf.patch \
	file://0553-drivers-stm32_remoteproc-support-of-the-non-secure-l.patch \
	file://0554-drivers-stm32_remoteproc-restore-firewall-on-low-pow.patch \
	file://0555-drivers-stm32_remoteproc-introduce-cleanup-of-firmwa.patch \
	file://0556-pta-stm32mp-remoteproc-implement-the-PTA_REMOTEPROC_.patch \
	file://0557-ta-stm32mp-invoke-clean-resources-on-stop-or-on-erro.patch \
	file://0558-dts-stm32-add-Cortex-M33-remoteproc-node-in-stm32mp2.patch \
	file://0559-dts-stm32-add-the-support-of-the-M33-remote-processo.patch \
	file://0560-dts-stm32-update-m4_rproc-to-support-the-remoteproc-.patch \
	file://0561-drivers-stm32_rifsc-add-RIMU-logic-reconfiguration-A.patch \
	file://0562-drivers-stm32_rifsc-add-RISUP-logic-reconfiguration-.patch \
	file://0563-plat-stm32mp2-enable-async-notif-with-GIC-PPI-15.patch \
	file://0564-plat-stm32mp2-conf-enable-TA-PKCS11.patch \
	file://0565-plat-stm32mp1-conf-enable-TA-PKCS11.patch \
	file://0566-drivers-stm32_bsec3-parse-nvmem-layout-after-loading.patch \
	file://0567-dts-stm32-add-backup-registers-configuration-for-stm.patch \
	file://0568-dts-stm32-add-backup-registers-configuration-for-stm.patch \
	file://0569-plat-stm32mp2-add-A35-standardized-status-and-contro.patch \
	file://0570-clk-stm32mp25-remove-direct-access-to-CA35SS_SYSCFG-.patch \
	file://0571-dts-stm32-force-v5v_vconn-always-on-for-stm32mp257f-.patch \
	file://0572-drivers-stm32mp2_pmic-handle-alternate-input-source-.patch \
	file://0573-dts-stm32-share-pmic-regulators-for-non-secure-world.patch \
	file://0574-dts-stm32-set-fast-pull-down-on-BUCK6-on-stm32mp257f.patch \
	file://0575-plat-stm32mp1-add-function-do_reset.patch \
	file://0576-plat-stm32mp1-call-do_reset-for-PSCI-system-reset.patch \
	file://0577-plat-stm32mp2-add-function-do_reset.patch \
	file://0578-drivers-stm32_tamp-remove-link-to-PSCI.patch \
	file://0579-drivers-stm32mp2_pmic-handle-over-current-protection.patch \
	file://0580-dts-stm32-Update-over-current-protection-on-stm32mp2.patch \
	file://0581-dts-stm32-vdd_sdcard-not-always-on-for-stm32mp257f-e.patch \
	file://0582-dts-stm32-VDDGPU-no-more-always-on-for-stm32mp257f-e.patch \
	file://0583-dts-stm32-share-PMIC-vdd3v3_usb-for-stm32mp257f-ev1.patch \
	file://0584-dts-stm32-VDDGPU-no-more-always-on-for-stm32mp257f-d.patch \
	file://0585-dts-stm32-vdd_sdcard-not-always-on-for-stm32mp257f-d.patch \
	file://0586-dts-stm32-Update-over-current-protection-on-stm32mp2.patch \
	file://0587-dts-stm32-add-tamper-pin-nodes-for-stm32mp15x.patch \
	file://0588-drivers-regulator-update-vrefbuf-driver-for-STM32MP2.patch \
	file://0589-plat-stm32mp2-conf-enable-VREFBUF.patch \
	file://0590-core-dt_driver-support-DT_DRIVER_NOTYPE-in-fdt_get_d.patch \
	file://0591-core-add-interrupt-notifications.patch \
	file://0592-plat-stm32mp1-add-stm32mp1_pwr_irq-driver.patch \
	file://0593-plat-stm32mp1-stm32mp_pmic-handle-stpmic1-IRQs.patch \
	file://0594-dts-stm32-Enable-PWR-IRQs-for-stm32mp135f-dk.patch \
	file://0595-dts-stm32-add-wake-up-parent-in-pwr_irq-node.patch \
	file://0596-plat-stm32mp2-stm32mp25_pwr-implement-wake-up-pins.patch \
	file://0597-plat-stm32mp2-conf-enable-PWR-interrupts.patch \
	file://0598-dts-stm32mp25-add-wake-up-pin-support-on-stm32mp2.patch \
	file://0599-dts-stm32-add-wake-up-parent-for-pmic2-on-stm32mp257.patch \
	file://0600-dts-stm32-describe-wake-up-parent-for-pmic2-on-stm32.patch \
	file://0601-dts-stm32-introduce-stm32mp23-SoCs-family.patch \
	file://0602-dts-stm32-add-stm32mp235f-dk-board-support.patch \
	file://0603-plat-stm32mp2-conf-support-STM32MP23x-SoC-family.patch \
	file://0604-dt-bindings-shared-bindings-between-STM32MP25x-and-S.patch \
	file://0605-drivers-stm32_remoteproc-support-STM32MP23x-SoC-fami.patch \
	file://0606-drivers-stm32_tamp-support-STM32MP23x-SoC-family.patch \
	file://0607-drivers-stm32_uart-support-STM32MP23x-SoC-family.patch \
	file://0608-core-mmu-add-MEM_AREA_ROM_SEC-in-check_mem_map.patch \
	file://0609-dt-bindings-add-STM32MP21-clocks-and-resets-bindings.patch \
	file://0610-dt-bindings-add-STM32MP21-RIFSC-bindings.patch \
	file://0611-dt-bindings-add-STM32MP21x-shared-bindings.patch \
	file://0612-plat-stm32mp2-update-SRAM1-base-address-for-STM32MP2.patch \
	file://0613-dts-st-introduce-stm32mp21-SoCs-family.patch \
	file://0614-dts-stm32-add-STM32MP21-pinctrl-DT-file.patch \
	file://0615-plat-stm32mp2-scmi_server-add-STM32MP21-support.patch \
	file://0616-plat-stm32mp2-conf-support-STM32MP21x-SoC-family.patch \
	file://0617-clk-stm32mp21-introduce-STM32MP21-clock-driver.patch \
	file://0618-plat-stm32mp2-update-clock-driver-flag-for-STM32MP21.patch \
	file://0619-drivers-stm32_tamp-support-STM32MP21x-SoC-family.patch \
	file://0620-drivers-stm32_bsec3-add-STM32MP21-version-support.patch \
	file://0621-plat-stm32mp2-conf-enable-single-core-for-STM32MP21.patch \
	file://0622-drivers-add-rstctrl-driver-for-STM32MP21.patch \
	file://0623-plat-stm32mp2-update-rstctrl-driver-flag-for-STM32MP.patch \
	file://0624-drivers-stm32_rifsc-differentiate-STM32MP2x-RIFSC-im.patch \
	file://0625-plat-stm32mp2-Disable-EXTI-for-STM32MP215x-boards.patch \
	file://0626-plat-stm32mp2-scmi_server-remove-OSPI2-reset-for-STM.patch \
	file://0627-core-io-fix-IO_READ32_POLL_TIMEOUT-when-delay-is-0us.patch \
	file://0628-drivers-add-counter-framework.patch \
	file://0629-drivers-add-stm32-lptimer.patch \
	file://0630-drivers-update-counter-framework-to-manage-configura.patch \
	file://0631-drivers-add-stm32-timer.patch \
	file://0632-drivers-counter-stm32_lptimer-add-support-for-stm32m.patch \
	file://0633-plat-stm32mp1-conf-enable-timers-and-lptimer-drivers.patch \
	file://0634-dts-activate-lptimer3-for-stm32mp135-disco-boards.patch \
	file://0635-plat-stm32mp2-conf-enable-lptimer-driver.patch \
	file://0636-dts-stm32-add-lptimer-nodes-in-stm32mp251.dtsi.patch \
	file://0637-plat-stm32mp1-add-hse-monitoring-feature.patch \
	file://0638-plat-stm32mp1-conf-add-hse-monitoring-support-on-stm.patch \
	file://0639-plat-stm32mp2-add-hse-monitoring-feature.patch \
	file://0640-plat-stm32mp2-conf-add-hse-monitoring-support-on-stm.patch \
	file://0641-plat-stm32mp1-add-calibration-driver.patch \
	file://0642-plat-stm32mp1-conf-enable-HSI-CSI-clock-calibration.patch \
	file://0643-clk-stm32mp25-add-clock-calibration-for-HSI-MSI-cloc.patch \
	file://0644-dts-stm32-enable-hse-monitoring-for-stm32mp135f-dk-b.patch \
	file://0645-dts-stm32-add-frequency-monitor-to-stm32mp251.dtsi-S.patch \
	file://0646-dts-stm32mp1-add-the-calibration-node.patch \
	file://0647-dts-stm32-add-HSI-CSI-calibration-on-STM32MP135F-DK.patch \
	file://0648-dts-stm32-add-HSI-CSI-calibration-on-STM32MP15x-boar.patch \
	file://0649-dts-stm32-activate-HSI-calibration-on-STM32MP25-boar.patch \
	file://0650-dts-stm32-activate-HSI-calibration-on-STM32MP23-boar.patch \
	file://0651-drivers-regulator-list-voltages-controlled-by-a-GPIO.patch \
	file://0652-plat-stm32mp1-scmi-rely-on-regulator-consumer-for-vo.patch \
	file://0653-drivers-scmi-msg-support-performance-domains-for-DVF.patch \
	file://0654-plat-stm32mp1-add-function-to-check-the-supported-OP.patch \
	file://0655-plat-stm32mp1-CPU-DVFS-support.patch \
	file://0656-plat-stm32mp1-SCMI-performance-domain-for-CPU-DVFS.patch \
	file://0657-dts-stm32mp13-add-operating-point-nodes-and-configur.patch \
	file://0658-dts-stm32mp13-describe-cpu-power-supply-on-stm32mp13.patch \
	file://0659-plat-stm32mp1-conf-enable-SCMI-PERF-for-stm32mp13.patch \
	file://0660-plat-stm32mp1-stm32mp_pmic-handle-secure-state-via-f.patch \
	file://0661-plat-stm32mp1-stm32mp_pmic-remove-i2c-power-manageme.patch \
	file://0662-plat-stm32mp1-scmi-simplify-find_-for-deterministic-.patch \
	file://0663-plat-stm32mp1-conf-update-flavorlist-MP15-HUK-DT.patch \
	file://0664-dts-stm32-default-disable-TAMP-node-on-STM32MP13x-bo.patch \
	file://0665-dts-stm32mp15-describe-cpu-power-supply-on-stm32mp15.patch \
	file://0666-dts-stm32mp15-add-operating-point-nodes-and-configur.patch \
	file://0667-crypto-stm32-use-HASH-IP-for-HASH-and-HMAC-algorithm.patch \
	file://0668-drivers-crypto-stm32_saes-add-pm-to-SAES-driver.patch \
	file://0669-crypto-stm32-use-PKA-IP-for-ECC-algorithm.patch \
	file://0670-crypto-stm32-PKA-limit-driver-support-to-ECDSA-and-E.patch \
	file://0671-drivers-stm32_uart-fix-incorrect-USART_ISR_TXFE-valu.patch \
	file://0672-dts-stm32-enable-SAES-on-stm32mp257f-ev1.patch \
	file://0673-dts-stm32-enable-SAES-on-stm32mp257f-dk.patch \
	file://0674-plat-stm32mp2-conf-enable-SAES-for-stm32mp2-platform.patch \
	file://0675-dts-stm32-add-SAES-and-PKA-dependency-on-RNG-clock-f.patch \
	file://0676-plat-stm32mp2-conf-disable-CRYP-when-SAES-is-enabled.patch \
	file://0677-dts-stm32-enable-HASH-on-stm32mp135f-dk.patch \
	file://0678-plat-stm32mp1-conf-disable-CRYP-when-SAES-is-enable-.patch \
	file://0679-plat-stm32mp1-conf-default-enable-HASH.patch \
	file://0680-plat-stm32mp2-conf-enable-HASH-for-stm32mp2-platform.patch \
	file://0681-dts-stm32-enable-HASH-on-stm32mp257f-ev1.patch \
	file://0682-dts-stm32-enable-HASH-on-stm32mp257f-dk.patch \
	file://0683-plat-stm32mp1-conf-default-enable-PKA.patch \
	file://0684-plat-stm32mp2-conf-enable-PKA-for-stm32mp2-platforms.patch \
	file://0685-plat-stm32mp2-conf-enable-CRYP-for-stm32mp2-platform.patch \
	file://0686-dts-stm32-enable-PKA-on-stm32mp257f-ev1.patch \
	file://0687-dts-stm32-enable-PKA-on-stm32mp257f-dk.patch \
	file://0688-dts-stm32-enable-PKA-on-stm32mp135f-dk.patch \
	file://0689-dts-stm32-secure-lptimer1-for-clock-calibration-on-s.patch \
	file://0690-dts-stm32-secure-lptimer1-for-clock-calibration-on-s.patch \
	file://0691-plat-stm32mp1-default-enable-hardware-RNG-for-STM32M.patch \
	file://0692-drivers-clk-clk-stm32mp15-allow-PM-without-CPU-DVFS.patch \
	file://0693-dts-stm32-update-name-of-RCC-pll-node-on-STM32MP25-b.patch \
	file://0694-dts-stm32-set-the-GPIOs-used-for-wake-up-as-secure-o.patch \
	file://0695-dts-stm32-add-stm32mp215f-dk-board.patch \
	file://0696-plat-stm32mp2-conf-support-stm32mp215f-dk-board.patch \
	file://0697-drivers-stm32_gpio-add-stm32_gpio_get_bank_id-helper.patch \
	file://0698-dts-stm32-prepare-use-of-GPIO-instead-of-pinctrl-for.patch \
	file://0699-drivers-stm32_tamp-use-GPIO-instead-of-pinctrl-for-e.patch \
	file://0700-drivers-stm32_tamp-manage-dependency-on-the-RNG.patch \
	file://0701-dts-stm32-use-GPIO-instead-of-pinctrl-for-external-t.patch \
	file://0702-drivers-stm32_risaf-protect-configuration-against-no.patch \
	file://0703-drivers-clk-stm32mp25-consider-OS-scheduler-on-polli.patch \
	file://0704-drivers-clk-fix-coding-style-issues-in-stm32mp25-clo.patch \
	file://0705-plat-stm32mp1-stm32mp_pmic-handle-st-mask-reset.patch \
	file://0706-plat-stm32mp1-stm32mp_pmic-add-property-st-regulator.patch \
	file://0707-dts-stm32-fix-wake-up-from-Standby-for-stm32mp13-boa.patch \
	file://0708-dts-stm32-fix-wake-up-from-Standby-for-stm32mp15-boa.patch \
	file://0709-dts-stm32-fix-wake-up-from-Standby-for-stm32mp15-dhc.patch \
	file://0710-dts-stm32-add-i2c2-to-i2c6-and-i2c8-nodes-in-stm32mp.patch \
	file://0711-dts-stm32-add-missing-i2c1-and-i2c2-instances-in-stm.patch \
	file://0712-drivers-stm32_omm-fix-region-overlap-check.patch \
	file://0713-plat-stm32mp2-sysconfig-simplify-amcr-check-size.patch \
	file://0714-.gitignore-Change-entries-to-only-ignore-in-the-sour.patch \
	file://0715-.gitignore-Ignore-all-dot-files-and-folders-except-t.patch \
	file://0716-drivers-stm32_omm-always-clock-OSPI-instances-if-mux.patch \
	file://0717-dts-stm32-rename-IOM-EVAL-pins-muxing-configurations.patch \
	file://0718-dts-stm32-rename-IOM-EVAL-pins-muxing-on-stm32mp257f.patch \
	file://0719-core-pm-add-unregister_pm_cb.patch \
	file://0720-drivers-stm32_gpio-save-restore-consumed-GPIOs-in-PM.patch \
	file://0721-drivers-stm32_gpio-rename-stm32_gpio_pm.patch \
	file://0722-core-kernel-ensure-RPC-argument-mobj-on-Ocall-contex.patch \
	file://0723-drivers-rstctrl-make-stm32mp15-controllers-unpaged.patch \
	file://0724-dts-stm32-default-disable-TAMP-node-in-stm32mp2x-SoC.patch \
	file://0725-drivers-crypto-stm32-clean-function-references.patch \
	file://0726-drivers-crypto-stm32-move-context-allocation-free-fu.patch \
	file://0727-drivers-crypto-stm32-cleanup-cipher-operation-struct.patch \
	file://0728-drivers-crypto-stm32_saes-fallback-to-software-on-19.patch \
	file://0729-plat-stm32mp1-default-enable-SAES-software-fallback.patch \
	file://0730-plat-stm32mp1-add-a-function-to-enable-monitoring-in.patch \
	file://0731-plat-stm32mp2-add-a-function-to-enable-monitoring-in.patch \
	file://0732-drivers-stm32_tamp-enable-monitoring-in-PWR-for-asso.patch \
	file://0733-dts-stm32-add-second-instance-of-watchdog.patch \
	file://0734-plat-stm32mp1-add-ahb2-bus-support.patch \
	file://0735-drivers-dt_driver-refine-register-provider-cases.patch \
	file://0736-core-add-adc-framework.patch \
	file://0737-drivers-stm32_adc-add-adc-driver-for-stm32mp13.patch \
	file://0738-drivers-stm32_adc-ensure-adc-reference-voltage-is-co.patch \
	file://0739-drivers-stm32_adc-add-pm-support-to-adc-driver.patch \
	file://0740-core-adc_fw-add-services-to-framework.patch \
	file://0741-drivers-stm32_adc-add-watchdog-support-for-stm32mp13.patch \
	file://0742-core-arm-add-OSTLv5-legacy-ARM-SMC-watchdog-0xb20000.patch \
	file://0743-drivers-stm32_risaf-handle-RISAF-illegal-access-flag.patch \
	file://0744-drivers-stm32_risab-handle-RISAB-illegal-access-flag.patch \
	file://0745-drivers-stm32_cpu_opp-prepare-for-scp-firmware-CPU-D.patch \
	file://0746-plat-stm32mp2-add-cpu_opp-support.patch \
	file://0747-fdts-stm32-describe-cpu-opp-for-STM32MP2.patch \
	file://0748-plat-stm32mp2-conf-enable-cpu_opp.patch \
	file://0749-plat-stm32mp2-conf-enable-SCP-DVFS.patch \
	file://0750-dts-add-stm32-frequency-monitor-to-stm32mp131.patch \
	file://0751-clk-stm32mp1-add-dsb-in-clock-driver.patch \
	file://0752-plat-stm32mp1-stm32mp1_pwr-add-dsb-in-pwr-driver.patch \
	file://0753-plat-stm32mp1-syscfg-add-dsb-in-syscfg-driver.patch \
	file://0754-plat-stm32mp1-discard-deprecated-CFG_STM32MP1_SCMI_S.patch \
	file://0755-drivers-crypto-remove-assertions-on-device-handlers.patch \
	file://0756-drivers-regulator-fix-error-case-in-regulator_suppor.patch \
	file://0757-drivers-regulator-split-regulator_supported_voltages.patch \
	file://0758-dts-stm32-set-LDO1-to-VOUT4-input-source-on-stm32mp2.patch \
	file://0759-drivers-stm32mp2_pmic-improve-PMIC-version-display.patch \
	file://0760-drivers-stm32mp2_pmic-improve-bypass-voltage-handlin.patch \
	file://0761-drivers-stm32mp2_pmic-driver-can-send-notification-t.patch \
	file://0762-dts-stm32-notify-PMIC-PKEY-IRQ-on-stm32mp25-boards.patch \
	file://0763-dt-bindings-mfd-describe-STM32MP25-PWR.patch \
	file://0764-dt-bindings-regulator-rework-STPMIC2-documentation.patch \
	file://0765-treewide-stm32mp2-fix-PMIC2-st-property-names.patch \
	file://0766-plat-stm32mp1-fix-calibration-failed.patch \
	file://0767-plat-stm32mp1-fix-untimely-HSE-over-frequency-warnin.patch \
	file://0768-dt-bindings-cleanup-binding-documentation-for-STM32M.patch \
	file://0769-plat-stm32mp1-update-hse-monitoring-feature.patch \
	file://0770-dt-bindings-update-device-tree-bindings-documentatio.patch \
	file://0771-drivers-stm32_bsec3-add-stm32_bsec_self_hosted_debug.patch \
	file://0772-plat-stm32mp2-enable-ck_sys_atb-ck_icn_m_etr-clock-i.patch \
	file://0773-clk-stm32mp25-add-clock-dependency-from-BSEC-DENR.patch \
	file://0774-clk-stm32mp25-program-c1msrd-during-suspend.patch \
	file://0775-clk-stm32mp25-gate-GPU-before-enabling-PLL3.patch \
	file://0776-plat-stm32mp1-conf-enable-the-provisioning-driver.patch \
	file://0777-dts-stm32-disable-IWDG1-and-IWDG2-during-low-power-o.patch \
	file://0778-dts-stm32-disable-IWDG1-and-IWDG2-during-low-power-o.patch \
	file://0779-dts-stm32-disable-IWDG1-and-IWDG2-during-low-power-o.patch \
	file://0780-dts-stm32-disable-IWDG1-and-IWDG2-during-low-power-f.patch \
	file://0781-dts-stm32-disable-semaphore-of-RNG-on-stm32mp257f-ev.patch \
	file://0782-plat-stm32mp1-remove-BSEC-SIP-services.patch \
	file://0783-drivers-stm32_saes-add-STM32MP21-support-for-SAES.patch \
	file://0784-plat-stm32mp1-conf-enable-ADC-support-on-stm32mp13-p.patch \
	file://0785-regulator-add-new-ops-init-to-configure-the-driver-c.patch \
	file://0786-plat-stm32mp1-stm32mp1_pmic-add-regulator-configurat.patch \
	file://0787-plat-stm32mp2-stm32mp2_pmic-add-regulator-configurat.patch \
	file://0788-drivers-crypto-stm32-lower-verbosity-on-device-use.patch \
	file://0789-clk-stm32mp21-add-clock-dependency-from-BSEC-DENR.patch \
	file://0790-stm32mp25-send-a-pulse-on-NRSTC1MS-pin-for-DBG_STAND.patch \
	file://0791-drivers-stm32_remoteproc-simplify-stm32_rproc_map_me.patch \
	file://0792-drivers-stm32_remoteproc-disable-trustzone-on-low-po.patch \
	file://0793-plat-stm32mp2-manage-non-secure-reset-request-for-th.patch \
	file://0794-plat-stm32mp2-add-HPDMA-Address-Remapping-SYSCFG-sup.patch \
	file://0795-dt-bindings-dma-add-st-syscfg-arcr-property-to-st-st.patch \
	file://0796-drivers-stm32_hpdma-add-Address-Remapping-configurat.patch \
	file://0797-dts-stm32-enable-AXI-address-remapping-for-HPDMA-on-.patch \
	file://0798-plat-stm32mp-set-initial-DVFS-OPP-when-using-SCP-fir.patch \
	file://0799-core-kernel-thread-spin-locking.patch \
	file://0800-core-kernel-mutex-compliant-with-PM-sequences.patch \
	file://0801-drivers-stm32_i2c-protect-bus-access-with-a-mutex.patch \
	file://0802-drivers-regulator-use-mutex_pm_aware.patch \
	file://0803-dts-stm32mp15-harden-RCC-secure-configuration-on-ST-.patch \
	file://0804-plat-stm32mp1-stm32mp1_pwr-fix-compatible.patch \
	file://0805-drivers-rstctrl-add-dsb-in-stm32mp1-driver.patch \
	file://0806-drivers-stm32_cpu_opp-add-missing-inclusion-in-heade.patch \
	file://0807-drivers-stm32_rifsc-provide-new-API-for-CID-filterin.patch \
	file://0808-plat-stm32mp2-stm32mp25_pwr-manage-CID-filtering-whe.patch \
	file://0809-dt-bindings-stm32_tamp-add-STM32MP21-tamper-bindings.patch \
	file://0810-drivers-stm32_tamp-update-handling-of-TAMP-wakeup-EX.patch \
	file://0811-core-drivers-update-stm32mp_dt_bindings.h-with-TAMP-.patch \
	file://0812-drivers-stm32_tamp-handle-LSE-monitoring-tamper.patch \
	file://0813-dts-stm32-set-tampers-as-a-wakeup-source-for-stm32mp.patch \
	file://0814-dts-stm32-set-tampers-as-a-wakeup-source-for-stm32mp.patch \
	file://0815-dts-stm32-set-TAMP-as-a-wake-up-source-on-stm32mp135.patch \
	file://0816-plat-stm32mp2-differentiate-internal-tamper-activati.patch \
	file://0817-treewide-st-remove-deprecated-pins-are-numbered-in-d.patch \
	file://0818-dts-stm32-add-a-default-backup-register-configuratio.patch \
	file://0819-dts-stm32-add-a-default-backup-register-configuratio.patch \
	file://0820-dts-stm32-add-a-default-backup-register-configuratio.patch \
	file://0821-drivers-stm32_tamp-force-the-use-of-st-backup-zones-.patch \
	file://0822-stm32mp1-use-generic-PM_HINT-and-associated-macro.patch \
	file://0823-stm32mp2-adapt-RISAF-device-tree-bindings-for-STM32M.patch \
	file://0824-drivers-stm32_risaf-differentiate-STM32MP2x-RISAF-im.patch \
	file://0825-clk-stm32mp1_rcc-remove-unused-defines.patch \
	file://0826-drivers-stm32_gpio-add-support-for-stm32mp21.patch \
	file://0827-core-firewall-add-firewall-framework.patch \
	file://0828-drivers-rstctrl-support-of-IWDG-timeout-event-to-res.patch \
	file://0829-plat-stm32mp1-STM32MP15-without-secure-service-can-s.patch \
	file://0830-core-pta-ask-for-enumeration.patch \
	file://0831-core-pta-RTC-enumerates-upon-RTC-registration.patch \
	file://0832-core-add-CFG_WITH_TRNG-y-n-to-allow-building-without.patch \
	file://0833-core-crypto-rng_hw-register-unregister-TRNG.patch \
	file://0834-core-rng_support-helper-function-to-register-TRNG.patch \
	file://0835-core-drivers-TRNG-driver-register-their-devices.patch \
	file://0836-plat-stm32mp1-let-DTB-register-TRNG.patch \
	file://0837-core-pta-HWRNG-enumerate-upon-registration.patch \
	file://0838-plat-stm32mp2-check-SCMI-M33-reset-access-upon-CFG_S.patch \
	file://0839-plat-stm32mp1-conf-move-definitions.patch \
	file://0840-plat-stm32mp1-conf-fix-no-cryp-no-rng-flavors.patch \
	file://0841-plat-stm32mp1-add-OP-TEE-resource-manager-configurat.patch \
	file://0842-plat-stm32mp2-add-OP-TEE-resource-manager-configurat.patch \
	file://0843-plat-stm32mp1-print-configuration-profile.patch \
	file://0844-plat-stm32mp2-print-configuration-profile.patch \
	file://0845-dts-stm32-enable-HASH-on-stm32mp215f-dk.patch \
	file://0846-dts-stm32-enable-PKA-on-stm32mp215f-dk.patch \
	file://0847-dts-stm32-enable-SAES-on-stm32mp215f-dk.patch \
	file://0848-dts-stm32-remove-the-pins-are-numbered-property.patch \
	file://0849-dt-bindings-regulator-add-STM32MP21-regulator-bindin.patch \
	file://0850-core-drivers-add-mailbox-framework.patch \
	file://0851-core-pta-add-optee-mailbox-framework-test.patch \
	file://0852-drivers-stm32_ipcc-add-mailbox-support.patch \
	file://0853-core-pta-add-optee-mailbox-user-for-test.patch \
	file://0854-core-drivers-mailbox-add-device-capabilities.patch \
	file://0855-drivers-stm32_ipcc-add-capabilities-ops-provided-by-.patch \
	file://0856-dts-stm32-add-IPCC1-interrupts-to-stm32mp2x-platform.patch \
	file://0857-plat-stm32mp2-add-mailbox-driver-support.patch \
	file://0858-dts-stm32-add-pinmux-for-console-on-stm32mp215f-dk.patch \
	file://0859-dts-stm32-add-console-to-stm32mp215f-dk.patch \
	file://0860-dts-stm32-enable-support-for-IWDG1-on-stm32mp215f-dk.patch \
	file://0861-dts-stm32-add-IWDG2-node-in-stm32mp21x-soc-device-tr.patch \
	file://0862-dts-stm32-add-I2C3-pinmux-for-stm32mp215f-dk.patch \
	file://0863-dts-stm32-add-support-for-I2C3-for-stm32mp215f-dk.patch \
	file://0864-dts-stm32-add-mlahb-node-on-stm32mp21.patch \
	file://0865-dts-stm32-add-support-of-m33_rproc-for-stm32mp215f-d.patch \
	file://0866-plat-stm32mp2-fix-memory-leak-in-scmi_scpfw_cfg_init.patch \
	file://0867-drivers-stm32_risaf-upgrade-RISAF-as-a-firewall-cont.patch \
	file://0868-plat-stm32mp2-default-enable-CFG_DRIVERS_FIREWALL.patch \
	file://0869-dts-stm32-declare-RISAF-instances-as-access-controll.patch \
	file://0870-ARM-dts-Add-OPP-for-STM32MP13-Industrial-Overdrive-p.patch \
	file://0871-drivers-regulator-add-regulator_get_by_name.patch \
	file://0872-stm32mp2-add-power-domain-device-tree-bindings.patch \
	file://0873-product-optee-stm32mp2-create-stm32-power-domain-mod.patch \
	file://0874-product-optee-stm32mp2-mod_stm32_pd-add-behavior-for.patch \
	file://0875-product-optee-stm32mp2-mod_stm32_pd-prevent-pd-modul.patch \
	file://0876-plat-stm32mp2-add-SCMI-power-domain-set-up.patch \
	file://0877-plat-stm32mp2-scmi_server-prepare-for-new-agent.patch \
	file://0878-plat-stm32mp2-scmi-factorize-channel-filling-into-a-.patch \
	file://0879-plat-stm32mp-scmi_server_scpfw-do-not-panic-during-s.patch \
	file://0880-plat-stm32mp2-scmi-add-scmi_scpfw_attach_notif-helpe.patch \
	file://0881-plat-stm32mp2-scmi_server-add-SCMI-CortexM33-agent-a.patch \
	file://0882-plat-stm32mp2-scmi-add-new-driver-scmi_cortexm_agent.patch \
	file://0883-plat-stm32mp2-scmi_server-enable-OPTEE_SMT-module-in.patch \
	file://0884-core-scmi-server-regulator-enable-multiple-instances.patch \
	file://0885-core-scmi-server-regulator-use-agent_id-and-channel_.patch \
	file://0886-dts-stm32-add-a-new-SCMI-agent-for-CortexM33-on-stm3.patch \
	file://0887-dts-st-add-scmi-agent-id-in-scmi_regu-node-in-stm32m.patch \
	file://0888-dts-st-add-scmi-agent-id-in-scmi_regu-node-in-stm32m.patch \
	file://0889-dts-st-add-scmi-agent-id-in-scmi_regu-node-in-stm32m.patch \
	file://0890-dts-st-add-scmi-agent-id-in-scmi_regu-node-in-stm32m.patch \
	file://0891-arch-add-tfm-architecture.patch \
	file://0892-product-add-tfm-stm32mp2-product.patch \
	file://0893-core-add-quiet-option.patch \
	file://0894-product-tfm-stm32mp2-set-minimal-banner.patch \
	file://0895-product-optee-stm32mp2-add-compatibility-with-optee-.patch \
	file://0896-dts-st-add-stm32mp215f-dk-system-configuration.patch \
	file://0897-core-lib-scmi-server-add-CMake-defines-for-embedded-.patch \
	file://0898-core-lib-scmi-server-drop-CFG_CROSS_COMPILE-when-com.patch \
	file://0899-drivers-stm32_rng-register-secure-state-base-on-fire.patch \
	file://0900-plat-stm32mp1-conf-disable-compilation-of-PKA-and-SA.patch \
	file://0901-dts-stm32-set-ipcc1-chan-13-to-16-to-CPU1-SEC-CPU2-N.patch \
	file://0902-checkpatch-discard-line-starting-with-Change-Id.patch \
	file://0903-core-scmi-server-fix-optee-stm32mp-modules-directive.patch \
	file://0904-scpfw-fix-CFG_SCPFW_MOD_-for-product-modules.patch \
	file://0905-core-scmi-server-default-value-for-CFG_SCPFW_MOD_STM.patch \
	file://0906-dts-stm32-add-STM32MP23-RCC-and-RIF-configuration-fo.patch \
	file://0907-dts-stm32-update-stm32mp231.dtsi.patch \
	file://0908-dts-stm32-update-stm32mp235-dk.dts.patch \
	file://0909-dts-stm32-define-ETZPC-as-an-access-controller-for-s.patch \
	file://0910-dts-stm32-remove-include-of-ETZPC-bindings-in-stm32m.patch \
	file://0911-dts-stm32-define-ETZPC-as-an-access-controller-for-s.patch \
	file://0912-dts-stm32-remove-include-of-ETZPC-bindings-in-stm32m.patch \
	file://0913-drivers-stm32_etzpc-use-generic-firewall-API.patch \
	file://0914-plat-stm32mp1-default-enable-CFG_DRIVERS_FIREWALL.patch \
	file://0915-drivers-stm32_etzpc-add-stm32_etzpc_check_ns_access.patch \
	file://0916-plat-stm32mp1-deprecate-stm32_firewall-use-in-scmi-s.patch \
	file://0917-drivers-stm32_i2c-inform-when-the-non-secure-compati.patch \
	file://0918-plat-stm32mp1-drivers-drop-usage-of-old-firewall-in-.patch \
	file://0919-drivers-stm32_rng-deprecate-stm32_firewall-usage.patch \
	file://0920-drivers-stm32_iac-handle-stm32mp21-SoC-particulariti.patch \
	file://0921-dts-stm32-define-RIFSC-as-an-access-controller-for-s.patch \
	file://0922-dts-stm32-define-RIFSC-as-an-access-controller-for-s.patch \
	file://0923-dts-stm32-define-RIFSC-as-an-access-controller-for-s.patch \
	file://0924-dts-stm32-remove-include-of-RIF-bindings-in-stm32mp2.patch \
	file://0925-dts-stm32-remove-include-of-RIF-bindings-in-stm32mp2.patch \
	file://0926-dts-stm32-use-access-controllers-for-ommanager-on-st.patch \
	file://0927-dts-stm32-use-access-controllers-for-ommanager-on-st.patch \
	file://0928-drivers-stm32_rifsc-rework-RIFSC-driver-as-a-firewal.patch \
	file://0929-drivers-stm32_omm-deprecate-stm32_firewall-usage.patch \
	file://0930-drivers-stm32_rif-add-CIDCFGR-macros.patch \
	file://0931-drivers-stm32_exti-use-generic-CIDCFGR-macros.patch \
	file://0932-drivers-stm32_hsem-use-generic-CIDCFGR-macros.patch \
	file://0933-drivers-stm32_rif-rework-RIF-device-tree-parsing.patch \
	file://0934-drivers-stm32_rifsc-use-only-one-argument-in-firewal.patch \
	file://0935-dts-stm32-reduce-access-controllers-cells-to-1-on-st.patch \
	file://0936-dts-stm32-reduce-access-controllers-cells-to-1-on-st.patch \
	file://0937-dts-stm32-reduce-access-controllers-cells-to-1-on-st.patch \
	file://0938-drivers-stm32_etzpc-update-DECPROT-macro.patch \
	file://0939-drivers-stm32_etzpc-use-only-one-argument-in-firewal.patch \
	file://0940-drivers-stm32_rif-remove-unused-macros.patch \
	file://0941-dts-stm32-describe-power-supplies-of-stm32mp215f-dk.patch \
	file://0942-plat-stm32mp2-enable-GIC-PM-support.patch \
	file://0943-drivers-counter-stm32_lptimer-add-support-for-stm32m.patch \
	file://0944-dts-st-add-low-power-timer-2-5-nodes-on-stm32mp211.patch \
	file://0945-drivers-stm32mp_provisioning-fix-unpaged-low-power-s.patch \
	file://0946-drivers-stm32mp_provisioning-is-dedicated-to-develop.patch \
	file://0947-core-dt_driver-add-dt_driver_count_devices.patch \
	file://0948-core-firewall-add-alternate-configuration-API.patch \
	file://0949-core-firewall-add-memory-range-firewall-controller-o.patch \
	file://0950-drivers-stm32_risab-handle-differently-RISAB-base-ad.patch \
	file://0951-drivers-stm32_risab-do-not-set-CID-configuration-if-.patch \
	file://0952-drivers-stm32_risab-rework-parse_risab_rif_conf.patch \
	file://0953-drivers-stm32_risab-rework-configuration-setting-API.patch \
	file://0954-dts-stm32-declare-RISAB-instances-as-firewall-contro.patch \
	file://0955-dts-stm32-declare-RISAB-instances-as-firewall-contro.patch \
	file://0956-dts-stm32-declare-RISAB-instances-as-firewall-contro.patch \
	file://0957-drivers-stm32_risab-upgrade-RISAB-as-a-firewall-cont.patch \
	file://0958-plat-stm32mp2-remove-filtering-on-exposed-SCMI-reset.patch \
	file://0959-drivers-stm32_firewall-remove-old-proprietary-firewa.patch \
	file://0960-plat-stm32mp2-remove-unused-CFG_STM32_FIREWALL-confi.patch \
	file://0961-drivers-stm32_risab-clear-SRWIAD-bit-if-property-not.patch \
	file://0962-scmi_perf-Correct-the-return-status-of-scmi_perf_pro.patch \
	file://0963-dts-stm32mp2-add-CRYP2-node-in-device-tree.patch \
	file://0964-drivers-stm32_bsec3-fix-OTP-parsing-to-retrieve-the-.patch \
	file://0965-plat-stm32mp2-add-stm32mp21-support-in-power-drivers.patch \
	file://0966-plat-stm32mp2-add-stm32mp21-compatibles-in-power-dri.patch \
	file://0967-dts-stm32-update-powers-compatible-in-stm32mp211.dts.patch \
	file://0968-core-pager-fix-arguments-passed-to-calloc-in-alloc_m.patch \
	file://0969-core-arm-fix-calloc-against-GCC-14-Wcalloc-transpose.patch \
	file://0970-libtomcrypt-fix-calloc-against-GCC-14-Wcalloc-transp.patch \
	file://0971-dt-bindings-st-stm32-calibration-add-STM32MP25-suppo.patch \
	file://0972-clk-stm32mp13-determine-rate-return-error-on-unsuppo.patch \
	file://0973-clk-stm32mp25-determine-rate-return-error-on-unsuppo.patch \
	file://0974-drivers-clk-use-ops-determine_rate-in-clk_round_rate.patch \
	file://0975-drivers-stm32_cpu_opp-skip-OPP-with-unsupported-freq.patch \
	file://0976-drivers-stm32_cpu_opp-use-the-supported-voltage-for-.patch \
	file://0977-plat-stm32mp2-power-domains-remove-panic-when-regula.patch \
	file://0978-drivers-stm32mp2_pmic-handle-STPMIC1L-and-STPMIC2L.patch \
	file://0979-drivers-stpmic2-allow-STM32MP1-to-use-STPMIC2.patch \
	file://0980-plat-stm32mp1-rework-PMIC-usages.patch \
	file://0981-plat-stm32mp1-rename-PMIC1-plat-file.patch \
	file://0982-core-add-a-feature-to-store-logs-in-RAM.patch \
	file://0983-drivers-stm32_uart-configure-UART-baudrate-register.patch \
	file://0984-plat-stm32mp1-remove-init-console-from-DTB.patch \
	file://0985-plat-stm32mp2-remove-init-console-from-DTB.patch \
	file://0986-drivers-stm32_uart-Make-UART-init-from-dt-only-durin.patch \
	file://0987-drivers-stm32_uart-rely-on-DT-for-initial-console-pi.patch \
	file://0988-drivers-stm32_tamp-rely-on-DT-for-initial-tamper-pin.patch \
	file://0989-drivers-stm32_i2c-rely-on-DT-for-initial-tamper-pin-.patch \
	file://0990-drivers-clk-stm32-rcc-rely-on-DT-for-initial-MCO-pin.patch \
	file://0991-drivers-stm32_gpio-do-not-change-GPIO-secure-state-i.patch \
	file://0992-plat-stm2mp1-remove-redundant-pin-secure-configurati.patch \
	file://0993-core-firewall-fix-warning-when-compiling-with-no-tra.patch \
	file://0994-dts-stm32mp151-add-address-cells-size-cells-in-rcc-n.patch \
	file://0995-plat-stm32mp2-replace-CFG_WARN_INSECURE-usage.patch \
	file://0996-clk-stm32mp21-add-clock-calibration-for-HSI-MSI-cloc.patch \
	file://0997-dts-stm32-activate-HSI-calibration-on-STM32MP215f-dk.patch \
	file://0998-drivers-stm32_risaf-cleanup-DT-related-definitions.patch \
	file://0999-drivers-stm32_risaf-add-a-check-for-region-encryptio.patch \
	file://1000-drivers-stm32_uart-remove-unused-pinctrl-sleep.patch \
	file://1001-dts-stm32-add-firewall-alternate-conf-property-for-o.patch \
	file://1002-drivers-stm32_omm-use-firewall-alternate-configurati.patch \
	file://1003-dts-stm32-use-access-controllers-conf-default-for-om.patch \
	file://1004-dts-stm32-add-shadow-provisionning-of-HCONF1-on-stm3.patch \
	file://1005-dts-stm32-add-pll1-configuration-for-1.5GHz-on-stm32.patch \
	file://1006-core-kernel-from_-to_bounce_params-relates-to-CFG_WI.patch \
	file://1007-framework-add-prefix-when-printing-a-log-trace.patch \
	file://1008-core-lib-scmi-server-add-log-prefix-support-for-SCP-.patch \
	file://1009-fwk_io-fix-GCC14-warning-in-fwk_io_vprintf.patch \
	file://1010-drivers-stm32_remoteproc-remove-temporary-st-s_memor.patch \
	file://1011-drivers-stm32_remoteproc-use-firewall_dt_get_alterna.patch \
	file://1012-drivers-stm32_remoteproc-add-API-to-get-and-release-.patch \
	file://1013-pta-stm32mp-remoteproc-implement-the-PTA_REMOTEPROC_.patch \
	file://1014-ta-remoteproc-Add-PTA-call-to-get-access-right-to-th.patch \
	file://1015-drivers-stm32_remoteproc-remove-memory-protection-wa.patch \
	file://1016-drivers-stm32_remoteproc-Add-the-support-of-the-stm3.patch \
	file://1017-drivers-stm32_risab-configure-SWRIAD-after-all-other.patch \
	file://1018-core-add-stm32_ltdc-driver.patch \
	file://1019-drivers-add-frame_buffer-driver-support.patch \
	file://1020-libutee-add-Trusted-UI-code.patch \
	file://1021-core-add-pseudo-TA-for-TUI.patch \
	file://1022-libutee-add-TUI-interface-and-implementation.patch \
	file://1023-libpng-import-library-version-to-1.6.37.patch \
	file://1024-zlib-move-zlib-from-core-to-lib-to-share-with-TAs.patch \
	file://1025-scripts-render_font.py-for-Python-3.x.patch \
	file://1026-scripts-render_font.py-use-PIL.patch \
	file://1027-scripts-fix-code-style-issues-in-render_font.py.patch \
	file://1028-libpng-fix-build-issue-when-NEON-is-disabled.patch \
	file://1029-plat-stm32mp1-display-add-wrapper.patch \
	file://1030-plat-stm32mp1-conf-enable-the-trusted-UI-support-for.patch \
	file://1031-plat-stm32mp2-display-add-wrapper.patch \
	file://1032-plat-stm32mp2-conf-enable-the-trusted-UI-support-for.patch \
	file://1033-dts-stm32-add-ltdc-pins-settings-for-stm32mp135f-dk.patch \
	file://1034-dts-stm32mp13-add-display-support-for-stm32mp135f-dk.patch \
	file://1035-dts-stm32-add-ltdc-support-on-stm32mp2.patch \
	file://1036-dts-stm32-use-compatible-st-stm32mp215-pinctrl-for-s.patch \
	file://1037-plat-stm32mp2-set-CFG_RESERVED_VASPACE_SIZE-to-32-MB.patch \
	file://1038-drivers-stm32_ltdc-fix-uninitialized-variable.patch \
	file://1039-core-firewall-fix-firewall_dt_get_by_name.patch \
	file://1040-plat-stm32mp2-conf-add-CFG_STM32_CM33TDCID.patch \
	file://1041-clk-stm32mp25-fix-RIF-configuration-checking.patch \
	file://1042-clk-stm32mp25-do-not-reset-flexgen-crossbar-input-if.patch \
	file://1043-clk-stm32mp25-do-not-access-BSEC-if-CFG_STM32_BSEC3-.patch \
	file://1044-clk-stm32mp21-do-not-access-BSEC-if-CFG_STM32_BSEC3-.patch \
	file://1045-plat-stm32mp2-access-BSEC-only-if-CFG_STM32_BSEC3-is.patch \
	file://1046-plat-stm32mp2-conf-disable-some-features-if-M33-is-T.patch \
	file://1047-drivers-stm32_gpio-support-non-TDCID-probe-and-RIF-c.patch \
	file://1048-drivers-stm32_ipcc-support-non-TDCID-probe-and-RIF-c.patch \
	file://1049-drivers-stm32_rifsc-support-non-TDCID-probe-and-RIF-.patch \
	file://1050-drivers-stm32_risab-support-non-TDCID-probe-and-RIF-.patch \
	file://1051-plat-stm32mp2-stm32mp25_pwr-support-non-TDCID-mode.patch \
	file://1052-drivers-stm32_rtc-do-not-require-the-presence-of-st-.patch \
	file://1053-drivers-stm32_exti-do-not-require-the-presence-of-st.patch \
	file://1054-drivers-stm32_fmc-do-not-require-the-presence-of-st-.patch \
	file://1055-drivers-stm32_hpdma-do-not-require-the-presence-of-s.patch \
	file://1056-drivers-stm32_tamp-support-non-TDCID-probe-and-RIF-c.patch \
	file://1057-drivers-stm32_ipcc-fix-consistency-checking-in-CID-c.patch \
	file://1058-tfm-ensure-std-gnu11-compiler-flag-is-not-overridden.patch \
	file://1059-dts-stm32-update-ETHCK-on-STM32MP215F-DK-board.patch \
	file://1060-dts-stm32-default-enable-TAMP-button-on-stm32mp257f-.patch \
	file://1061-dts-stm32-default-enable-TAMP-button-on-stm32mp257f-.patch \
	file://1062-dts-stm32-default-enable-TAMP-button-on-stm32mp235f-.patch \
	file://1063-dts-stm32-default-enable-TAMP-and-RTC-for-every-SoC.patch \
	file://1064-dts-stm32-remove-activation-of-TAMP-and-RTC-nodes-at.patch \
	file://1065-dt-bindings-update-YAML-documentation-for-stm32mp25-.patch \
	file://1066-dts-stm32-update-remoteproc-node-compatible.patch \
	file://1067-drivers-remoteproc-stm32-Fix-address-size-handling-i.patch \
	file://1068-dts-stm32-Fix-ranges-and-dma-range-property-of-mlahb.patch \
	file://1069-dts-stm32-Fix-ranges-and-dma-range-property-of-mlahb.patch \
	file://1070-dts-stm32-Fix-ranges-and-dma-range-property-of-mlahb.patch \
	file://1071-dts-stm32-add-iwdg2-node-on-stm32mp23-platform.patch \
	file://1072-clk-cpu_opp-provide-the-OPP-node-to-STM32MP15-RCC-dr.patch \
	file://1073-drivers-stm32_cpu_opp-init-from-cpu-node.patch \
	file://1074-drivers-stm32_cpu_opp-export-opp_voltage_is_supporte.patch \
	file://1075-plat-stm32mp2-stm32mp25_pwr-fix-wake-up-pins-binding.patch \
	file://1076-dts-stm32-describe-vrefbuf-supply-for-stm32mp25.patch \
	file://1077-dts-stm32-describe-vrefbuf-supply-for-stm32mp21.patch \
	file://1078-dts-stm32-describe-vrefbuf-supply-for-stm32mp23.patch \
	file://1079-plat-stm32mp-introduce-GPU-OPP-driver.patch \
	file://1080-dts-stm32-add-GPU-OPP-description.patch \
	file://1081-plat-stm32mp2-default-enable-CFG_STM32_GPU_OPP.patch \
	file://1082-drivers-stm32_rifsc-implement-errata-on-RIMUs.patch \
	file://1083-drivers-stm32_risab-implement-errata-on-RISABs.patch \
	file://1084-drivers-stm32_hpdma-implement-errata-on-HPDMA.patch \
	file://1085-core-scmi-server-update-SCP-Firmware-version-display.patch \
	file://1086-drivers-clk-restore-clock-on-stm32_gate_ready_endisa.patch \
	file://1087-clk-stm32mp25-fix-restore-of-composite-clock.patch \
	file://1088-drivers-clk-fix-error-cases-in-STM32MP25-clocks.patch \
	file://1089-drivers-clk-don-t-mix-error-codes-in-stm32mp25-drive.patch \
	file://1090-clk-stm32mp21-fix-restore-of-composite-clock.patch \
	file://1091-drivers-clk-fix-error-cases-in-STM32MP21-clocks.patch \
	file://1092-drivers-clk-don-t-mix-error-codes-in-stm32mp21-drive.patch \
	file://1093-dt-bindings-soc-add-risal-description.patch \
	file://1094-drivers-stm32_rifsc-add-STM32-RISAL-support-for-stm3.patch \
	file://1095-dts-stm32-add-risal-node-on-stm32mp257f-ev1.patch \
	file://1096-dts-stm32-Change-LPUART-clock-on-stm32mp257f-dk-boar.patch \
	file://1097-dts-stm32-Change-LPUART-Clock-on-stm32mp257f-ev1-boa.patch \
	file://1098-drivers-stm32_rifsc-restrain-access-on-non-secure-pe.patch \
	file://1099-drivers-stm32_etzpc-restrain-access-on-non-secure-pe.patch \
	file://1100-drivers-firewall-stm32_etzpc-don-t-include-keep.h.patch \
	file://1101-clk-stm32mp15-enable-all-outputs-PQR-at-the-PLL-conf.patch \
	file://1102-drivers-stm32_adc-Add-support-for-adc-on-stm32mp25.patch \
	file://1103-drivers-stm32_adc-Add-support-for-adc-on-stm32mp21.patch \
	file://1104-drivers-stm32_adc-Add-support-for-adc-on-stm32mp23.patch \
	file://1105-dts-st-add-ADC-nodes-on-stm32mp251.patch \
	file://1106-dts-st-add-ADC-nodes-on-stm32mp211.patch \
	file://1107-dts-st-add-ADC-nodes-on-stm32mp231.patch \
	file://1108-libutee-tui-force-image-alpha-color-to-0xFF.patch \
	file://1109-drivers-clean-cache-of-frame_buffer.patch \
	file://1110-plat-stm32mp2-enable-remoteproc-driver-in-optee-syst.patch \
	file://1111-drivers-stm32_remoteproc-Add-reset-controller-suppor.patch \
	file://1112-dts-stm32mp-add-reset-support-for-remoteproc-on-stm3.patch \
	file://1113-plat-stm32mp2-remove-filtering-on-exposed-SCMI-reset.patch \
	file://1114-drivers-rstctrl-fix-function-description.patch \
	file://1115-dt-bindings-mfd-dual-licensing-for-st-stpmic1-bindin.patch \
	file://1116-dts-stm32-remove-export-vddgpu-on-stm32mp25.patch \
	file://1117-plat-stm32mp2-enable-debug-on-STM32MP21.patch \
	file://1118-core-make-is_initializing-field-a-generic-service-co.patch \
	file://1119-core-add-mutex_is_locked-helper-function.patch \
	file://1120-core-fix-race-condition-on-TA-PTA-StMM-context-loadi.patch \
	file://1121-scripts-fix-pycodestyle-complain.patch \
	file://1122-plat-stm32mp1-add-internal-RAMs-memory-layout-in-pla.patch \
	file://1123-drivers-stm32_etzpc-use-memory-configuration-firewal.patch \
	file://1124-dts-stm32mp15-align-reserved-memory-definitions-with.patch \
	file://1125-drivers-stm32_remoteproc-use-firewall_dt_get_alterna.patch \
	file://1126-dts-stm32-update-mlahb-dma-range-for-the-stm32mp15-s.patch \
	file://1127-dts-stm32-add-firewall-configs-for-remoteproc-on-stm.patch \
	file://1128-drivers-stm32_bsec3-move-OEM_KEY_FIRST_OTP-to-platfo.patch \
	file://1129-plat-stm32mp2-update-BSEC-fuse-map-for-STM32MP21.patch \
	file://1130-dts-stm32mp15-remove-useless-gpio-regulator-property.patch \
	file://1131-dts-stm32-assign-lpuart1-pins-to-Cortex-M0-on-stm32m.patch \
	file://1132-dts-arm-configure-ipcc2-access-rights-for-Cortex-M0-.patch \
	file://1133-dts-stm32-change-default-d3-domain-source-clock-on-s.patch \
	file://1134-dts-arm-configure-ipcc2-access-rights-for-Cortex-M0-.patch \
	file://1135-dts-stm32-change-default-d3-domain-source-clock-on-s.patch \
	file://1136-drivers-stpmic2-update-lp-mode-only-when-it-changes.patch \
	file://1137-plat-stm32mp2-add-GPU-to-probe-bus-RIF-exceptions.patch \
	file://1138-drivers-stm32_rtc-remove-includes-and-reorder-macros.patch \
	file://1139-drivers-stm32_rtc-remove-specific-time-structure-to-.patch \
	file://1140-plat-stm32mp2-add-support-for-secure-RTC.patch \
	file://1141-drivers-stm32_rtc-add-set_time-and-get_time-ops.patch \
	file://1142-drivers-rtc-add-support-of-alarm-in-RTC-API.patch \
	file://1143-drivers-rtc-add-time-comparison-in-RTC-API.patch \
	file://1144-core-pta-verify-RTC-PTA-data-buffer-is-aligned-with-.patch \
	file://1145-core-pta-add-alarm-related-operations-to-RTC-PTA.patch \
	file://1146-plat-stm32mp1-force-the-compilation-of-RTC-framework.patch \
	file://1147-drivers-stm32_rtc-replace-stm32_is_a_leap_year-with-.patch \
	file://1148-drivers-stm32_rtc-add-alarm-related-operations-and-i.patch \
	file://1149-dts-stm32-add-wakeup-properties-to-the-RTC.patch \
	file://1150-drivers-stm32_rtc-add-the-capability-to-wakeup-the-p.patch \
	file://1151-dts-stm32-let-ETR-to-access-kernel-memory-on-stm32mp.patch \
	file://1152-drivers-stm32_iwdg-add-stop-watchdog-handler.patch \
	file://1153-dts-stm32-add-reset-property-for-IWDG2.patch \
	file://1154-drivers-stm32_iwdg-Add-support-for-extended-watchdog.patch \
	file://1155-drivers-scm-msg-fix-clock-rates-description-remainin.patch \
	file://1156-drivers-clk-fix-stm32mp13-round_rate-on-PLLs-max-div.patch \
	file://1157-libutils-qsort-helper-for-standard-types.patch \
	file://1158-plat-stm32mp1-leverage-qsort_int-in-PMIC-driver.patch \
	file://1159-drivers-stm32mp_pmic2-leverage-qsort_int-in-PMIC-dri.patch \
	file://1160-drivers-clk-clk_get_rates_array-returns-ordered-rate.patch \
	file://1161-scpfw-module-optee-clock-get-min-max-clock-from-list.patch \
	file://1162-drivers-clk-stm32mp2-fix-header-file-inclusion-order.patch \
	file://1163-plat-stm32mp2-enumerate-clocks-by-arrays-where-appli.patch \
	file://1164-plat-stm32mp1-enumerate-clocks-by-arrays-where-appli.patch \
	file://1165-scpfw-module-scmi_clock-specifc-OSTLv4-v5-duty-cycle.patch \
	file://1166-drivers-scmi-msg-specific-OSTLv4-v5-duty-cycle-round.patch \
	file://1167-core-kernel-dt_driver-fix-nodes-reference-passed-in-.patch \
	file://1168-dt-bindings-gpio-stm32mp-flags-for-non-secure-GPIOs.patch \
	file://1169-dts-stm32-stm32mp2-wakeup-GPIO-are-secure.patch \
	file://1170-dts-stm32-stm32mp257f-ev1-ommanager-does-not-load-pi.patch \
	file://1171-dts-stm32-stm32mp13-fix-GPIOs-secure-state.patch \
	file://1172-dts-stm32-define-SoC-GPIO-banks-that-are-firewall-co.patch \
	file://1173-drivers-st32_fmc-consider-pinctrl_apply_state-return.patch \
	file://1174-drivers-st32_omm-consider-pinctrl_apply_state-return.patch \
	file://1175-drivers-stm32_gpio-check-GPIO-is-not-already-consume.patch \
	file://1176-drivers-stm32_gpio-factorize-apply_rif_config.patch \
	file://1177-drivers-stm32_gpio-register-to-firewall-framework.patch \
	file://1178-dts-stm32-LTDC-secure-non-secure-pinctrl-for-stm32mp.patch \
	file://1179-drivers-stm32_ltdc-remove-stm32_pinctrl_set_secure_c.patch \
	file://1180-drivers-stm32_gpio-remove-gpio-pinctrl-API-function-.patch \
	file://1181-drivers-stm32_gpio-check-state-of-consumed-GPIOs-pin.patch \
	file://1182-plat-stm32mp1-calib-remove-pager-constraints.patch \
	file://1183-plat-stm32mp1-calib-fix-header-files-inclusion.patch \
	file://1184-plat-stm32mp1-don-t-register-scmi-server-PM-if-not-n.patch \
	file://1185-plat-stm32mp1-move-console_init-to-init-section.patch \
	file://1186-drivers-clk-smt32mp15-stm32mp1_clk_on-is-local.patch \
	file://1187-core-mm-ensure-all-pager-VA-space-is-mapped-with-sma.patch \
	file://1188-plat-stm32mp1-pager-use-SYSRAM-last-page-if-possible.patch \
	file://1189-core-panic-clean-cache-before-issuing-WFI-instructio.patch \
	file://1190-core-panic-add-missing-inclusion-of-keep.h.patch \
	file://1191-core-arm-pageable-PM-sequences.patch \
	file://1192-core-kernel-update-pm-callback-constraints-to-pageab.patch \
	file://1193-core-kernel-consider-thread-PM-context-in-PM-aware-m.patch \
	file://1194-plat-stm32mp1-pageable-PM-sequences.patch \
	file://1195-plat-stm32mp1-pm-correct-header-file-inclusion-order.patch \
	file://1196-stm32mp15-tree-wide-use-DECLARE_KEEP_PAGER_PM.patch \
	file://1197-crypto-stm32-fix-SAES-driver-set_field_u32-usage.patch \
	file://1198-clk-stm32mp25-remove-support-of-st-clksrc.patch \
	file://1199-dts-stm32-remove-support-of-st-clksrc-on-stm32mp25-b.patch \
	file://1200-plat-stm32mp1-fix-low-power-mode-selection-with-STPM.patch \
	file://1201-drivers-stm32_cpu_opp-manage-OPP-for-all-SoC.patch \
	file://1202-drivers-stm32_uart-add-support-for-resume-and-suspen.patch \
	file://1203-plat-stm32mp2-add-suspend-resume-callback-for-HSE-mo.patch \
	file://1204-plat-stm32mp1-add-suspend-resume-callback-for-HSE-mo.patch \
	file://1205-product-tfm-stm32mp2-fix-module-clock.patch \
	file://1206-product-tfm-stm32mp2-fix-regu-module.patch \
	file://1207-product-tfm-stm32mp2-add-tfm_smt-module.patch \
	file://1208-module-Don-t-consider-OP-TEE-modules-when-SCP_OPTEE_.patch \
	file://1209-product-tfm-stm32mp2-add-GPU-power-domain-management.patch \
	file://1210-scripts-sign_rproc_fw-Add-support-for-AES-CBC-encryp.patch \
	file://1211-pta-remoteproc-Update-PTA_RPROC_LOAD_SEGMENT_SHA256-.patch \
	file://1212-ta-remoteproc-Get-hash-algorithm-from-TLV.patch \
	file://1213-pta-remoteproc-Add-support-of-the-elf-with-encryptio.patch \
	file://1214-ta-remoteproc-Update-e32_parser_find_rsc_table-to-by.patch \
	file://1215-ta-remoteproc-Add-support-of-encrypted-firmware.patch \
	file://1216-keys-Add-a-null-AES-32-bytes-key-for-remoteproc-encr.patch \
	file://1217-plat-stm32mp1-conf-get-HUK-location-from-the-DT-if-n.patch \
	file://1218-dts-stm32-stm32mp15-explicit-GPIOs-in-non-secure-sta.patch \
	file://1219-plat-stm32mp2-scmi_server-fix-typos-in-scmi-clock-li.patch \
	file://1220-dt-bindings-scmi-add-scmi-clock-flags.patch \
	file://1221-dts-stm32-describe-scmi-resources-for-stm32mp25x.patch \
	file://1222-dts-stm32-describe-scmi-resources-for-stm32mp23x.patch \
	file://1223-dts-stm32-describe-scmi-resources-for-stm32mp21x.patch \
	file://1224-dts-stm32-replace-resets-C2_R-and-C2_HOLDBOOT_R.patch \
	file://1225-plat-stm32mp2-get-scmi-resources-from-device-tree.patch \
	file://1226-plat-stm32mp2-scmi_server-implement-power-domain-pro.patch \
	file://1227-plat-stm32mp2-scmi_server-implement-clock-protocol.patch \
	file://1228-plat-stm32mp2-scmi_server-implement-voltage-domain-p.patch \
	file://1229-plat-stm32mp2-scmi_server-implement-reset-domain-pro.patch \
	file://1230-plat-stm32mp2-scmi_server-implement-dvfs-protocol.patch \
	file://1231-dts-stm32-allocate-RNG2-to-secure-for-stm32mp215f-dk.patch \
	file://1232-dt-bindings-pinctrl-stm32mp-flags-for-non-secure-pin.patch \
	file://1233-dts-stm32-most-stm32mp15-UARTs-pinctrl-are-non-secur.patch \
	file://1234-dts-stm32-refine-secure-and-non-secure-I2C4-pinctrl-.patch \
	file://1235-dts-stm32-refine-STM32MP13-secure-non-secure-USART4-.patch \
	file://1236-dts-stm32-refine-STM32MP21-secure-and-non-secure-USA.patch \
	file://1237-dts-stm32-refine-STM32MP23-MP35-secure-non-secure-US.patch \
	file://1238-drivers-stm32_gpio-check-pin-secure-state-of-pinctrl.patch \
	file://1239-core-define-plat_rng_init-as-a-weak-alias-of-__plat_.patch \
	file://1240-drivers-stm32_rng-use-default-PRNG-init-if-RNG-is-di.patch \
	file://1241-clk-stm32mp25-set-FMC-clock-as-critical.patch \
	file://1242-plat-stm32mp2-enable-all-OPP-support-for-M33TDCID.patch \
	file://1243-dts-stm32-update-stm32mp215f-dk-system-configuration.patch \
	file://1244-clk-stm32mp25-calibration-fix-HSI-deviation-paramete.patch \
	file://1245-clk-stm32mp25-calibration-HSI-calibration-was-stoppe.patch \
	file://1246-dt-bindings-clock-stm32mp25-add-IDs-of-Cortex-CM0-C3.patch \
	file://1247-clk-clk-stm32mp25-add-HSI-HSE-MSI-Kernel-clocks.patch \
	file://1248-clk-stm32mp25-add-management-of-autonomous-clocks.patch \
	file://1249-dts-stm32-add-SCMI-HSI-HSE-MSI-Kernel-clocks-for-stm.patch \
	file://1250-dts-stm32-add-SCMI-autonomous-clock-management-for-s.patch \
	file://1251-dts-stm32-add-SCMI-HSI-HSE-MSI-Kernel-clocks-for-stm.patch \
	file://1252-drivers-stm32_rstctrl-fix-unpaged-resource.patch \
	file://1253-drivers-regulator-change-tree-trace-level.patch \
	file://1254-dts-stm32-secure-LTDC-on-stm32mp135f-dk.patch \
	file://1255-plat-stm32mp1-fix-use-after-free-in-PMIC-driver.patch \
	file://1256-dts-stm32-add-ltdc-support-on-stm32mp21.patch \
	file://1257-dts-stm32-add-ltdc-support-on-stm32mp23.patch \
	file://1258-drivers-stm32_ltdc-apply-secure-pinctrl.patch \
	file://1259-dts-st-fix-timers-and-lptimers-node-in-stm32mp131.patch \
	file://1260-clk-stm32mp25-force-ARM_DIVSEL-for-flexgen63-config-.patch \
	file://1261-drivers-clk-change-tree-trace-level.patch \
	file://1262-dts-stm32-remove-export-vddgpu-on-stm32mp23.patch \
	file://1263-dts-stm32-add-wakeup-properties-to-the-RTC-for-stm32.patch \
	file://1264-dts-stm32-add-GPU-OPP-description-in-stm32mp235.dtsi.patch \
	file://1265-drivers-clk-stm32mp13-fix-clock-gate-init-state.patch \
	file://1266-drivers-clk-stm32-assert-refcount-on-clock-gates.patch \
	file://1267-core-dt-add-fdt_reg_base_ncells.patch \
	file://1268-lib-scmi-server-use-fdt_reg_base_ncells.patch \
	file://1269-libutils-add-bisect-helper-functions.patch \
	file://1270-core-pta-test-bisect-implementation.patch \
	file://1271-core-dt-cache-embedded-DTB-node-parent-information.patch \
	file://1272-core-dt-cache-embedded-DTB-node-phandles.patch \
	file://1273-plat-stm32mp1-conf-default-enable-CFG_DT_CACHED_NODE.patch \
	file://1274-plat-stm32mp2-conf-default-enable-CFG_DT_CACHED_NODE.patch \
	file://1275-product-tfm-stm32mp2-move-std-c11-compiler-flag.patch \
	file://1276-dts-stm32-default-disable-DMA-at-SoC-level-for-stm32.patch \
	file://1277-plat-stm32mp1-allow-probe-on-non-secure-timers-for-s.patch \
	file://1278-dts-stm32-remove-RIF-reference-to-the-Cortex-M0-for-.patch \
	file://1279-dts-stm32-remove-IPCC2-node-for-stm32mp23x-Socs.patch \
	file://1280-dts-stm32-add-risal-configuration-on-stm32mp257f-dk.patch \
	file://1281-clk-stm32mp25-fix-FLEXGEN-configuration-of-pred-divi.patch \
	file://1282-plat-stm32mp1-add-stm32mp1_pa_or_sram_alias_pa.patch \
	file://1283-plat-stm32mp1-add-stm32mp1_ram_intersect_pager_ram.patch \
	file://1284-drivers-stm32_etzpc-pager-SRAMs-must-be-secure.patch \
	file://1285-drivers-stm32_remoteproc-Don-t-use-SRAMs-used-by-pag.patch \
	file://1286-drivers-firewall-stm32_etzpc-allow-valid-locked-conf.patch \
	file://1287-plat-stm32mp1-use-firewall-framework-to-configure-in.patch \
	file://1288-drivers-stm32_remote_proc-add-stm32_rproc_is_secure.patch \
	file://1289-plat-stm32mp1-scmi_server-permit-MCU-reset-upon-remo.patch \
	file://1290-drivers-stm32_exti-execute-suspend-for-all-low-power.patch \
	file://1291-drivers-stpmic1-fix-potential-untreated-pending-irq.patch \
	file://1292-dt-bindings-scmi-add-scmi-bindings.patch \
	file://1293-drivers-stm32_gpio-fix-return-code-if-apply_rif_conf.patch \
	file://1294-core-lib-scmi-server-update-displayed-SCP-Firmware-v.patch \
	file://1295-scripts-sign_rproc_fw-fix-cryptography-import.patch \
	file://1296-drivers-stm32_exti-fix-IMR-for-all-low-power-modes.patch \
	file://1297-plat-stm32mp2-stm32mp25_pwr-restore-fixed-regulator.patch \
	file://1298-drivers-stm32_tamp-fix-switched-masks-when-applying-.patch \
	file://1299-plat-stm32mp2-add-PWR-pm-callbacks.patch \
	file://1300-drivers-stm32_rtc-fix-overflow-at-midnight.patch \
	file://1301-drivers-stm32_uart-handle-clock-disable-during-PM.patch \
	file://1302-drivers-clk-stm32mp15-add-is_enabled-ops.patch \
	file://1303-dts-stm32-remove-stm32mppll3-cfg-900Mhz-on-STM32MP23.patch \
	file://1304-dts-stm32-fix-GPU-OPP-description-for-STM32MP23x.patch \
	file://1305-drivers-stm32_bsec3-allow-driver-file-to-be-use-with.patch \
	file://1306-plat-stm32mp2-allow-BSEC-compilation-with-CM33-TDCID.patch \
	file://1307-drivers-stm32_bsec3-map-bsec_mirror-non-secure-if-M3.patch \
	file://1308-plat-stm32mp2-adapt-SRAM1-mapping-for-M33-TDCID.patch \
	file://1309-drivers-counter-remove-dynamic-allocation-in-PM-hand.patch \
	file://1310-dts-stm32-Fix-clock-source-of-STGEN-to-HSE_KER.patch \
	file://1311-drivers-stm32_cpu_opp-fix-allocation-leakage-in-erro.patch \
	file://1312-drivers-stm32_cpu_opp-fix-against-GCC-14-Wcalloc-tra.patch \
	file://1313-drivers-stm32_rif-align-with-upstream-RIF-APIs.patch \
	file://1314-clk-stm32mp25-make-RIF-configuration-not-mandatory.patch \
	file://1315-clk-stm32mp21-make-RIF-configuration-not-mandatory.patch \
	file://1316-clk-stm32mp25-handle-RIF-semaphores-when-non-TDCID.patch \
	file://1317-clk-stm32mp21-handle-RIF-semaphores-when-non-TDCID.patch \
	file://1318-plat-stm32mp2-fix-factorize-semaphore-handling-for-P.patch \
	file://1319-drivers-stm32_fmc-fix-and-factorize-semaphore-handli.patch \
	file://1320-drivers-stm32_gpio-fix-and-factorize-semaphore-handl.patch \
	file://1321-drivers-stm32_hpdma-fix-and-factorize-semaphore-hand.patch \
	file://1322-dt-bindings-remove-CLK_CFG-CMD_CLK-support-for-st-ke.patch \
	file://1323-clk-stm32mp21-determine-rate-return-error-on-unsuppo.patch \
	file://1324-clk-stm32mp21-do-not-reset-flexgen-crossbar-input-if.patch \
	file://1325-dt-bindings-add-HSI-HSE-MSI-Kernel-clock-bindings-fo.patch \
	file://1326-clk-clk-stm32mp21-add-HSI-HSE-MSI-Kernel-clocks.patch \
	file://1327-dts-stm32-add-SCMI-HSI-HSE-MSI-Kernel-clocks-for-stm.patch \
	file://1328-clk-stm32mp25-rename-RCC_USBTCCFGR-register-into-RCC.patch \
	file://1329-dts-stm32-enable-RTC-on-stm32mp215f-dk.patch \
	file://1330-dts-stm32-handle-orange-LED-on-stm32mp215f-dk.patch \
	file://1331-clk-stm32mp25-do-not-configure-PLL1-MUX-when-M33TDCI.patch \
	file://1332-clk-stm32mp25-check-RIF-access-for-HSI-HER-MSI-Kerne.patch \
	file://1333-dts-stm32-remove-LTDC-rotation-from-MP21-DK-RIF-RESM.patch \
	file://1334-dts-stm32-remove-LTDC-rotation-from-stm32mp215.dtsi.patch \
	file://1335-dt-bindings-soc-remove-LTDC-rotation-from-MP21-RISUP.patch \
	file://1336-dt-bindings-stm32_rng-add-RNG-support-for-STM32MP21.patch \
	file://1337-drivers-stm32_rng-add-RNG-support-for-STM32MP21.patch \
	file://1338-dts-stm32-add-RNG-support-for-STM32MP21.patch \
	file://1339-plat-stm32mp2-duplicate-agent-string-name-passed-to-.patch \
	file://1340-plat-stm32mp2-conf-disable-calibration-feature-if-M3.patch \
	file://1341-scpfw-product-stm32mp-shorten-vendor-identifiers.patch \
	file://1342-dts-stm32-fix-GIC-interrupt-ligns-in-stm32mp211.dtsi.patch \
	file://1343-drivers-stm32_risab-reorder-CID-filtering-configurat.patch \
	file://1344-dts-st-fix-length-of-SRAM1-regions.patch \
	file://1345-dts-stm32-fix-RTC-GIC-interrupt-ID-in-stm32mp211.dts.patch \
	file://1346-plat-stm32mp2-fix-erroneous-mapping-of-SRAM1.patch \
	file://1347-plat-stm32mp2-Fix-RESOURCES-define-name.patch \
	file://1348-clk-stm32mp25-remove-critical-clocks-when-not-tdcid.patch \
	file://1349-drivers-stm32_hpdma-restore-Address-Remapping-config.patch \
	file://1350-dts-stm32-fix-memory-ranges-on-fmc-node-for-mp251.patch \
	file://1351-dts-stm32-fix-memory-ranges-on-fmc-node-for-mp231.patch \
	file://1352-dts-stm32-fix-memory-ranges-on-fmc-node-for-mp211.patch \
	file://1353-plat-stm32mp2-use-software-PRNG-when-CFG_STM32_CM33T.patch \
	file://1354-plat-stm32mp1-stm32mp1_pwr-fix-wake-up-pins.patch \
	file://1355-drivers-stm32_rtc-fix-exti-wakeup-management.patch \
	file://1356-plat-stm32mp2-disable-stm32_debug_suspend-when-debug.patch \
	file://1357-dts-stm32-remove-vdd33ucpd-on-stm32mp215f-dk.patch \
	file://1358-dts-stm32-update-system-config-for-stm32mp257f-ev1.patch \
	file://1359-dts-stm32-update-system-config-for-stm32mp257f-dk.patch \
	file://1360-dts-stm32-update-system-config-for-stm32mp215f-dk.patch \
	file://1361-dts-stm32-update-system-config-for-stm32mp235f-dk.patch \
	file://1362-drivers-stm32_bsec3-force-miror-reload-after-a-stand.patch \
	file://1363-plat-stm32mp2-Enable-EXTI-for-STM32MP215x-boards.patch \
	file://1364-dts-stm32-enable-exti1-and-exti2-on-stm32mp211.patch \
	file://1365-drivers-stm32_rng-fix-RNG-conditional-reset-behavior.patch \
	file://1366-drivers-stm32_rng-enable-all-oscillator-in-STM32MP21.patch \
	file://1367-drivers-stm32_bsec3-rename-bsec-shadow-to-mirror.patch \
	file://1368-drivers-stm32_bsec3-update-bsec_mirror-struct.patch \
	file://1369-drivers-crypto-remove-192bits-key-software-fallback-.patch \
	file://1370-plat-stm32mp2-add-management-of-SAES-software-fallba.patch \
	file://1371-dt-bindings-scmi-rename-scmi-regulators-by-regulator.patch \
	file://1372-dts-stm32-do-not-expose-CA35-regulators-to-CM33-for-.patch \
	file://1373-dts-stm32-rename-scmi-regulators-by-regulator-0-for-.patch \
	file://1374-dts-stm32-rename-scmi-regulators-by-regulator-0-for-.patch \
	file://1375-dts-stm32-rename-scmi-regulators-by-regulator-0-for-.patch \
	file://1376-dts-stm32-rename-scmi-regulators-by-regulator-0-for-.patch \
	file://1377-dts-stm32-rename-scmi-regulators-by-regulator-0-for-.patch \
	file://1378-dts-stm32-rename-scmi-regulators-by-regulator-0-for-.patch \
	file://1379-pta-stm32mp-remoteproc-implement-read-of-encryption-.patch \
	file://1380-dts-stm32-add-OEM-rproc-encryption-key-for-stm32mp25.patch \
	file://1381-plat-stm32mp2-set-copro-encryption-test-flag-to-inse.patch \
	file://1382-dts-stm32-add-OEM-rproc-encryption-key-for-stm32mp23.patch \
	file://1383-dts-stm32-add-OEM-rproc-encryption-key-for-stm32mp21.patch \
	file://1384-pta-stm32mp-remoteproc-verify-legitimacy-of-public-k.patch \
	file://1385-plat-stm32mp2-add-copro-public-key-verify-flag.patch \
	file://1386-dts-stm32-add-OEM-rproc-public-key-hash-for-stm32mp2.patch \
	file://1387-dts-stm32-add-OEM-rproc-public-key-hash-for-stm32mp2.patch \
	file://1388-dts-stm32-add-OEM-rproc-public-key-hash-for-stm32mp2.patch \
	file://1389-clk-stm32mp21-do-not-configure-PLL1-MUX-when-M33TDCI.patch \
	file://1390-clk-stm32mp21-check-RIF-access-for-HSI-HSE-MSI-Kerne.patch \
	file://1391-plat-stm32mp2-stm32mp25_pwr-avoid-PM-operation-for-S.patch \
	file://1392-plat-stm32mp2-fix-power-level-description-on-stm32mp.patch \
	file://1393-core-delay-fix-timeout-expiration-threshold.patch \
	file://1394-drivers-stm32_stgen-rename-tsgen-to-stgen.patch \
	file://1395-clk-stm32mp21-configure-STGEN-flexgen-in-.enable-ops.patch \
	file://1396-clk-stm32mp25-configure-STGEN-flexgen-in-.enable-ops.patch \
	file://1397-drivers-stm32_stgen-remove-support-property-st-tsgen.patch \
	file://1398-dts-stm32-remove-provider-cells-properties-for-stm32.patch \
	file://1399-dts-stm32-remove-provider-cells-properties-for-stm32.patch \
	file://1400-dts-stm32-remove-provider-cells-properties-for-stm32.patch \
	file://1401-drivers-clk-stm32mp13-test-stm32_gate_rdy_disable-re.patch \
	file://1402-drivers-stm32_ipcc-fix-st-proc-id-offset-value.patch \
	file://1403-dts-stm32-add-st-proc-id-to-ipcc-nodes-in-stm32mp251.patch \
	file://1404-dts-stm32-add-st-proc-id-to-ipcc-node-in-stm32mp231..patch \
	file://1405-dts-stm32-add-st-proc-id-to-ipcc-node-in-stm32mp211..patch \
	file://1406-dts-stm32-add-ltdc-pins-settings-for-stm32mp215f-dk.patch \
	file://1407-libutils-util.h-add-usage-description-to-get-set-_fi.patch \
	file://1408-drivers-stm32_rng-fix-configuration-field-definition.patch \
	file://1409-dt-bindings-stm32_rng-add-RNG-customization-optional.patch \
	file://1410-drivers-stm32_rng-manage-RNG-customization-with-devi.patch \
	file://1411-plat-stm32mp1-align-Co-processor-config-flag-declara.patch \
	file://1412-firewall-stm32_etzpc-fix-check_access.patch \
	file://1413-drivers-clk-stm32mp25-correct-PLL3-enable-failure-ca.patch \
	file://1414-drivers-stm32_ipcc-restore-control-and-mask-register.patch \
	file://1415-drivers-stm32_stgen-remove-st-stm32mp1-stgen-from-th.patch \
	file://1416-product-tfm-stm32mp2-add-firewall-support-in-power-d.patch \
	file://1417-product-tfm-stm32mp2-fix-module-clock.patch \
	file://1418-arch-optee-helper-function-to-convert-TEE_Result-int.patch \
	file://1419-module-optee-clock-change-set_state-to-convert-error.patch \
	file://1420-module-scmi_clock-handle-SCMI_DENIED-in-set_request_.patch \
	file://1421-module-optee-clock-convert-TEE-results-to-framework-.patch \
	file://1422-module-optee-voltd_regulator-convert-TEE-results-to-.patch \
	file://1423-product-optee-stm32mp2-convert-TEE-results-to-framew.patch \
	file://1424-plat-stm32mp1-conf-default-enable-CFG_STM32_LTDC.patch \
	file://1425-dts-st-add-access-controllers-property-in-lp-timer-2.patch \
	file://1426-plat-stm32mp2-increase-heap-to-384kB.patch \
	file://1427-drivers-stm32_rifsc-remove-semaphore-acquisition-whe.patch \
	file://1428-drivers-stm32_bsec-add-stm32_bsec_self_hosted_debug_.patch \
	file://1429-pta-stm32mp-bsec-implement-a-BSEC-PTA-command-to-que.patch \
	file://1430-drivers-stm32_tamp-support-masking-potential-reset-f.patch \
	file://1431-plat-stm32mp2-add-stm32mp2_tamp-driver.patch \
	file://1432-plat-stm32mp2-disable-tamper-and-pwr-regulator-drive.patch \
	file://1433-dts-stm32-remove-unused-pin-definition-for-stm32mp-b.patch \
	file://1434-dts-stm32-keep-vddio2-and-vddio3-always-on-on-stm32m.patch \
	file://1435-drivers-stm32_rif-Check-availability-before-taking-a.patch \
	file://1436-arch-optee-protect-scmi_process_mbx_-with-mutexes.patch \
	file://1437-product-tfm-stm32mp2-update-for-tfm-v2.1.0.patch \
	file://1438-dts-stm32-change-LPTIM4-clock-for-LSI-for-stm32mp257.patch \
	file://1439-product-optee-stm32mp2-remove-scmi-server-from-scmi_.patch \
	file://1440-product-optee-stm32mp1-remove-scmi-server-from-scmi_.patch \
	file://1441-plat-stm32mp2-set-TEE_RAM_VA_SIZE-to-4Mb.patch \
	file://1442-drivers-stm32_bsec3-remove-duplicate-macros.patch \
	file://1443-drivers-stm32_bsec3-read-BSEC_SR-only-when-needed-in.patch \
	file://1444-dts-stm32-remove-always-on-from-vdd33ucpd-in-stm32mp.patch \
	file://1445-dts-stm32-remove-always-on-from-vdd33ucpd-in-stm32mp.patch \
	file://1446-dts-stm32-remove-always-on-from-vdd33ucpd-in-stm32mp.patch \
	file://1447-plat-stm32mp1-move-sanity-of-RCC-secure-state-agains.patch \
	file://1448-drivers-firewall-stm32_etzpc-explicit-index-in-DECPR.patch \
	file://1449-drivers-firewall-stm32_etzpc-consistent-RCC-DECPROT-.patch \
	file://1450-plat-stm32mp1-CFG_STM32_IWDG-requires-CFG_WDT_SM_HAN.patch \
	file://1451-drivers-stm32_iwdg-remove-registering-to-shared_reso.patch \
	file://1452-drivers-stm32_iwdg-remove-useless-device-list.patch \
	file://1453-drivers-stm32_rng-remove-registering-to-shared_resou.patch \
	file://1454-drivers-stm32_uart-remove-registering-to-shared_reso.patch \
	file://1455-drivers-stm32_cryp-remove-registering-to-shared_reso.patch \
	file://1456-drivers-stm32_i2c-rely-on-DT-compat-ID-for-secure-no.patch \
	file://1457-drivers-remoteproc-stm32mp15-check-Cortex-M-isolatio.patch \
	file://1458-drivers-clk-stm32mp15-default-disable-mckprot-harden.patch \
	file://1459-drivers-clk-stm32mp15-remove-unused-stm32mp1_clk_mcu.patch \
	file://1460-plat-stm32mp1-scmi_server-test-clock-access-against-.patch \
	file://1461-plat-stm32mp1-scmi_server-MP15-denies-GPIOZ-reset-do.patch \
	file://1462-plat-stm32mp1-scmi_server-don-t-expose-non-exclusive.patch \
	file://1463-plat-stm32mp1-remove-SCP-firmware-support.patch \
	file://1464-plat-stm32mp1-stm32mp1_stpmic1-remove-use-of-shared_.patch \
	file://1465-plat-stm32mp1-remove-unused-stm32mp_nsec_can_access_.patch \
	file://1466-plat-stm32mp1-remove-unused-stm32mp_nsec_can_access_.patch \
	file://1467-plat-stm32mp1-remove-unused-stm32mp_nsec_can_access_.patch \
	file://1468-plat-stm32mp1-remove-shared_resource-support-for-GPI.patch \
	file://1469-plat-stm32mp1-remove-deprecated-shared_resource-driv.patch \
	file://1470-plat-stm32mp2-remove-deprecated-shared_resource-stub.patch \
	file://1471-drivers-firewall-stm32_etzpc-remove-header-file.patch \
	file://1472-scp-remove-rejected-hunk-file.patch \
	file://1473-dts-stm32-move-scmi-server-configuration-in-a-separa.patch \
	file://1474-dts-stm32-reduce-scmi-server-configuration-for-STM32.patch \
	file://1475-dts-stm32-reduce-scmi-server-configuration-for-STM32.patch \
	file://1476-dts-stm32-reduce-scmi-server-configuration-for-STM32.patch \
	file://1477-drivers-stpmic2-fix-a-mistake-with-over-current-hand.patch \
	file://1478-core-psa-adac-dump-source-files-from-PSA-ADAC-git-tr.patch \
	file://1479-core-psa-adac-remove-unused-files-and-directories.patch \
	file://1480-core-plat-stm32mp2-put-lib-psa-adac-target-stuff-in-.patch \
	file://1481-core-psa-adac-add-skeleton-code-for-psa-adac-crypto-.patch \
	file://1482-core-psa-adac-fix-adac-crypto.c-compilation.patch \
	file://1483-core-psa-adac-fix-PSA_ADAC_LOG_-T-DUMP-with-snprintf.patch \
	file://1484-core-psa-adac-fix-compilation-issue-due-to-static_bu.patch \
	file://1485-libmbedtls-fix-redundant-declarations-for-psa_set_ke.patch \
	file://1486-core-psa-adac-make-it-buildable-as-library-for-optee.patch \
	file://1487-core-plat-stm32mp2-enable-CFG_PSA_ADAC-on-stm32mp21.patch \
	file://1488-dt-bindings-add-the-DBGMCU-secure-debug-mailbox-bind.patch \
	file://1489-drivers-add-driver-for-DBGMCU-secure-debug-mailbox-f.patch \
	file://1490-dts-stm32-add-DBGMCU-secure-debug-mailbox-on-stm32mp.patch \
	file://1491-core-plat-stm32mp2-psa-adac-implement-crypto-api.patch \
	file://1492-core-plat-stm32mp2-psa-adac-implement-transport-laye.patch \
	file://1493-core-plat-stm32mp2-retrieve-chip-device-id-from-sysc.patch \
	file://1494-drivers-stm32_bsec-bsec3-add-stm32_bsec_read_otp_ran.patch \
	file://1495-drivers-stm32_bsec3-add-stm32_bsec_mp21_ap0_unlock.patch \
	file://1496-dts-stm32-add-OEM-ADAC-ROTPK-hash-for-stm32mp21.patch \
	file://1497-dts-stm32-add-Unique-device-ID-UID-for-stm32mp21.patch \
	file://1498-core-plat-stm32mp2-psa-adac-implement-platform-api.patch \
	file://1499-drivers-stm32_dbgmcu_mbx-manage-secure-debug-request.patch \
	file://1500-dts-st-move-node-hash1-and-rng1-in-stm32mp211.dtsi.patch \
	file://1501-dts-st-add-access-controllers-property-in-for-crypto.patch \
	file://1502-dts-st-define-cryp2-node-in-stm32mp21xc.dtsi.patch \
	file://1503-drivers-stm32_serc-disable-SERC-during-suspend-seque.patch \
	file://1504-plat-stm32mp1-syscfg-set-SYSCFG_CMPCR_READY_TIMEOUT_.patch \
	file://1505-clk-stm32mp21-remove-define-CK_SCMI_ICN_VID.patch \
	file://1506-crypto-stm32-fix-PKA-ECDSA-and-ECDH-limitation-for-p.patch \
	file://1507-dts-stm32-fix-I2C3-pinmux-for-stm32mp215f-dk.patch \
	file://1508-drivers-stpmic2-allow-to-force-disable-regulator-dur.patch \
	file://1509-dts-stm32-disable-USB-and-GPU-supplies-in-standby-on.patch \
	file://1510-drivers-scmi-msg-move-static_assert-out-of-the-case-.patch \
	file://1511-drivers-remoteproc-rework-dma-range-management.patch \
	file://1512-drivers-remoteproc-convert-the-boot-address-to-PA-be.patch \
	file://1513-dts-stm32-update-dma-range-for-the-mlhab-node-for-st.patch \
	file://1514-plat-stm32mp1-remove-unused-function-dump_context.patch \
	file://1515-plat-stm32mp1-remove-unused-function-pm_cb_is_valid.patch \
	file://1516-plat-stm32mp1-remove-unused-function-stm32mp_pm_retr.patch \
	file://1517-plat-stm32mp1-simplify-print_ccm_decryption_duration.patch \
	file://1518-plat-stm32mp1-clean-definition-of-teeram_bkp_mm.patch \
	file://1519-plat-stm32mp1-simplify-CFG_STM32MP1_PM_CONTEXT_VERSI.patch \
	file://1520-plat-stm32mp1-add-support-of-CRC-support-in-pm-stand.patch \
	file://1521-plat-stm32mp1-select-CFG_STM32MP1_PM_CONTEXT_VERSION.patch \
	file://1522-dts-stm32-remove-OPP-400-on-stm32mp15x.patch \
	file://1523-drivers-stm32_cpu_opp-apply-default-OPP-during-suspe.patch \
	file://1524-drivers-rework-counter-API.patch \
	file://1525-drivers-stm32-lptimer-update-drivers-to-use-new-fram.patch \
	file://1526-plat-stm32mp1-replace-alarm-by-events-for-hse-monito.patch \
	file://1527-plat-stm32mp2-replace-alarm-by-events-for-hse-monito.patch \
	file://1528-drivers-remove-alarm-future-from-counter-API.patch \
	file://1529-drivers-stm32_exti-add-an-API-to-read-the-IMR-value.patch \
	file://1530-plat-stm32mp1-stm32mp1_pwr-retrieve-power-domain-sta.patch \
	file://1531-plat-stm32mp2-remove-unnecessary-check-from-pwr_set_.patch \
	file://1532-clk-clk-stm32mp25-fix-HSI-HSE-MSI-Kernel-clocks.patch \
	file://1533-mk-compile.mk-fix-header-dependency-in-.d-file.patch \
	file://1534-clk-stm32mp21-remove-critical-clocks-for-M33TDCID.patch \
	file://1535-clk-stm32mp21-check-RIF-access-for-MSI-clock.patch \
	file://1536-dt-bindings-fix-LTDC-layer-numbers-on-stm32mp2x-plat.patch \
	file://1537-plat-stm32mp2-stm32mp25_pwr-remove-fixme-in-driver.patch \
	file://1538-dts-stm32-expose-vdda18adc-regulator-to-CM33-agent-i.patch \
	file://1539-dts-stm32-expose-vdda18adc-regulator-to-CM33-agent-i.patch \
	file://1540-dts-stm32-expose-vdda18adc-regulator-to-CM33-agent-i.patch \
	file://1541-dt-bindings-mfd-define-st-iocomp-property-for-pwr-re.patch \
	file://1542-plat-stm32mp2-stm32mp25_pwr-allow-to-set-a-fixed-IO-.patch \
	file://1543-dts-stm32-add-fixed-IO-compensation-on-vddio-regulat.patch \
	file://1544-dts-stm32-add-fixed-IO-compensation-on-vddio-regulat.patch \
	file://1545-dts-stm32-add-fixed-IO-compensation-on-vddio-regulat.patch \
	file://1546-dts-stm32-fix-support-for-I2C3-on-stm32mp215f-dk.patch \
	file://1547-drivers-stm32_iwdg-reload-for-stopped-watchdog.patch \
	file://1548-product-tfm-stm32mp2-add-CFG_SCPFW_MOD_POWER_DOMAIN-.patch \
	file://1549-module-scmi_clock-move-static_assert-out-of-the-case.patch \
	file://1550-module-scmi-fix-scmi_api-respond-size.patch \
	file://1551-product-tfm-stm32mp2-module_reset-Add-missing-format.patch \
	file://1552-product-tfm-stm32mp2-module_reset-remove-extra-semi-.patch \
	file://1553-product-tfm-stm32mp2-tfm_clock-check-context-NULLity.patch \
	file://1554-core-arm-boot-enable-native-interrupts-before-initca.patch \
	file://1555-Squashed-commit-upgrading-to-mbedtls-3.6.0.patch \
	file://1556-core-mbedtls-Fix-build.patch \
	file://1557-libmbedtls-mbedtls_config_uta.h-enable-SHA-384-and-S.patch \
	file://1558-Squashed-commit-upgrading-to-mbedtls-3.6.2.patch \
	file://1559-libmbedtls-use-mempool_calloc-for-temporary-memory.patch \
	file://1560-plat-stm32mp2-set-unsafe-config-to-keep-performance.patch \
	file://1561-core-lib-add-rse_comms.patch \
	file://1562-plat-stm32mp2-add-psa-support-on-rse_comms.patch \
	file://1563-drivers-stm32_rng-add-a-PSA-call-in-M33TD-CID-config.patch \
	file://1564-module-scmi-assert-that-device-element_id-is-a-valid.patch \
	file://1565-plat-stm32mp1-shared_resource-stops-checking-clock-d.patch \
	file://1566-drivers-stm32mp_pmic2-drop-useless-include-file.patch \
	file://1567-core-interrupt-add-set_wake-for-power-management-wak.patch \
	file://1568-dt-bindings-update-documentation-of-st-stm32-exti.patch \
	file://1569-dts-stm32-align-EXTI-nodes-to-upstream-bindings-on-s.patch \
	file://1570-dts-stm32-align-EXTI-nodes-to-upstream-bindings-on-s.patch \
	file://1571-dts-stm32-align-EXTI-nodes-to-upstream-bindings-on-s.patch \
	file://1572-dts-stm32-align-EXTI-nodes-to-upstream-bindings-on-s.patch \
	file://1573-dts-stm32-pass-dummy-parameters-for-EXTI-phandle.patch \
	file://1574-drivers-stm32_exti-use-standard-DT-interrupt-type.patch \
	file://1575-drivers-stm32_exti-add-helper-stm32_exti_get_pdata.patch \
	file://1576-drivers-stm32_exti-use-interrupt_register_provider.patch \
	file://1577-drivers-stm32_exti-add-helper-for-direct-configurabl.patch \
	file://1578-drivers-stm32_exti-use-a-macro-for-lines-per-bank.patch \
	file://1579-drivers-stm32_exti-implement-hierarchical-irq-contro.patch \
	file://1580-drivers-stm32_tamp-get-interrupt-number-from-device-.patch \
	file://1581-dts-stm32-tamper-use-EXTI-interrupt-controller.patch \
	file://1582-drivers-stm32_tamp-drop-EXTI-wakeup-and-use-interrup.patch \
	file://1583-dts-stm32-drop-wakeup-parent-from-tamp-nodes.patch \
	file://1584-dts-stm32-use-EXTI-interrupt-for-RTC-nodes.patch \
	file://1585-drivers-stm32_rtc-drop-hardcoded-EXTI-callbacks.patch \
	file://1586-dts-stm32-drop-wakeup-parent-from-RTC-nodes.patch \
	file://1587-drivers-stm32_exti-predate-line-in-use.patch \
	file://1588-core-allow-sending-an-async-notif-from-notifier-atom.patch \
	file://1589-plat-stm32mp1-let-PWR-IRQ-to-propagate-to-parent-GIC.patch \
	file://1590-plat-stm32mp2-let-PWR-IRQ-to-propagate-to-parent-GIC.patch \
	file://1591-dts-stm32-add-generic-interrupt-bindings-for-PWR-IRQ.patch \
	file://1592-plat-stm32mp-move-threaded-interrupt-from-PWR-to-pmi.patch \
	file://1593-plat-stm32mp-convert-the-drivers-to-the-interrupt-fr.patch \
	file://1594-dts-stm32-drop-unsupported-interrupt-bindings-for-PW.patch \
	file://1595-plat-stm32mp1-make-PWR-IRQ-independent-from-EXTI.patch \
	file://1596-plat-stm32mp2-make-PWR-IRQ-independent-from-EXTI.patch \
	file://1597-dts-stm32-use-PWR-through-EXTI-on-stm32mp13x.patch \
	file://1598-dts-stm32-use-PWR-through-EXTI-on-stm32mp21x.patch \
	file://1599-dts-stm32-use-PWR-through-EXTI-on-stm32mp23x.patch \
	file://1600-dts-stm32-use-PWR-through-EXTI-on-stm32mp25x.patch \
	file://1601-plat-stm32mp1-drop-exti-references-from-PWR-IRQ.patch \
	file://1602-plat-stm32mp2-drop-exti-references-from-PWR-IRQ.patch \
	file://1603-drivers-stm32_exti-drop-wakeup-parent-magic-value.patch \
	file://1604-dts-stm32-add-wakeup-properties-to-the-RTC-for-stm32.patch \
	file://1605-product-tfm-stm32mp2-update-scmi-agents-file-name.patch \
	file://1606-plat-stm32mp1-add-DDRMCE-config-in-context-V3.patch \
	file://1607-dts-stm32-remove-interrupt-for-RTC-on-stm32mp13.patch \
	file://1608-scripts-sign_rproc_fw-change-the-format-of-the-encry.patch \
	file://1609-scripts-sign_rproc_fw-add-the-support-of-encrypted-s.patch \
	file://1610-pta-stm32mp-remoteproc-Rework-legitimacy-of-RSA-publ.patch \
	file://1611-pta-stm32mp-remoteproc-add-support-of-ECC-public-key.patch \
	file://1612-drivers-remoteproc-transform-some-debug-message-in-e.patch \
	file://1613-drivers-remoteproc-reinitialize-rproc-fields-in-stm3.patch \
	file://1614-dts-stm32-Update-LPTIM4-clock-source-to-LSI-for-stm3.patch \
	file://1615-drivers-scmi-msg-fix-default-OPP-latency-value.patch \
	file://1616-drivers-stm32_cpu_opp-improve-SCP-set-voltage.patch \
	file://1617-dts-stm32-fix-bad-GPU-clock-on-device-tree.patch \
	file://1618-dts-stm32-add-st-ck_gpu-node-for-stm32mp25-boards.patch \
	file://1619-clk-stm32mp25-add-management-of-GPU-OPPs.patch \
	file://1620-clk-stm32mp21-remove-CCB-clock.patch \
	file://1621-dt-bindings-stm32-remove-CCB-bindings.patch \
	file://1622-core-do-not-acknowledge-end-of-interrupt-for-special.patch \
	file://1623-drivers-stm32-core-use-DIV_ROUND_UP-instead-ROUNDUP_.patch \
	file://1624-drivers-stm32mp1_stpmic1-remove-unused-includes.patch \
	file://1625-drivers-stm32mp_pmic2-remove-unused-includes.patch \
	file://1626-plat-stm32mp1-cleanup-the-include-of-stpmic1-file.patch \
	file://1627-drivers-stpmic2-update-the-bindings.patch \
	file://1628-drivers-stpmic1-update-the-bindings.patch \
	file://1629-clk-stm32mp25-fix-autonomous-mode-support-for-periph.patch \
	file://1630-drivers-stm32_rif-add-mask-to-get-static-CID-of-a-pe.patch \
	file://1631-clk-stm32mp21-Check-Peripheral-RIF-assignation-befor.patch \
	file://1632-clk-stm32mp25-Check-Peripheral-RIF-assignation-befor.patch \
	file://1633-drivers-stm32_ltdc-sync-comment-with-code.patch \
	file://1634-drivers-stm32_ltdc-fix-shadow-registers-usage.patch \
	file://1635-clk-stm32mp21-dont-modify-reserved-RCC-RIF-registers.patch \
	file://1636-clk-error-when-set_rate-ops-is-not-supported.patch \
	file://1637-drivers-stm32_irq_notif-add-new-driver.patch \
	file://1638-plat-stm32mp1-conf-default-enable-CFG_STM32_IRQ_NOTI.patch \
	file://1639-dts-stm32-use-stm32-irq-notifier-instead-of-stm32mp1.patch \
	file://1640-plat-stm32mp1-remove-the-driver-stm32mp1-pwr-irq-use.patch \
	file://1641-plat-stm32mp2-remove-the-driver-stm32mp2x-pwr-irq-us.patch \
	file://1642-plat-stm32mp1-disable-parent-IRQ-only-when-all-PWR-c.patch \
	file://1643-plat-stm32mp2-disable-parent-IRQ-only-when-all-PWR-c.patch \
	file://1644-plat-stm32mp1-clean-WKUP-IRQ-management.patch \
	file://1645-plat-stm32mp2-clean-WKUP-IRQ-management.patch \
	file://1646-plat-stm32mp1-add-stm32_exti_base-function.patch \
	file://1647-plat-stm32mp1-stm32mp1_pwr-fix-access-to-EXTI-in-low.patch \
	file://1648-drivers-stm32_exti-remove-API-to-read-the-IMR-value.patch \
	file://1649-drivers-stm32_exti-drop-export-of-internal-API.patch \
	file://1650-plat-stm32mp2-stm32mp25_pwr-enable-clamp-workaround-.patch \
	file://1651-clk-stm32mp25-don-t-put-all-flexgen-clocks-as-critic.patch \
	file://1652-clk-stm32mp21-don-t-put-all-flexgen-clocks-as-critic.patch \
	file://1653-plat-stm32mp1-drop-unused-include-stm32mp_pm.h.patch \
	file://1654-plat-stm32mp1-drop-prototype-of-stm32_cores_reset.patch \
	file://1655-core-notif-fix-handling-of-masked-irq-notif.patch \
	file://1656-product-optee-stm32mp1-fix-default-latency-value.patch \
	file://1657-product-optee-stm32mp2-fix-default-latency-value.patch \
	file://1658-prod-tfm-stm32mp-remove-mutex-in-mailbox-module.patch \
	file://1659-prod-tfm-stm32mp-add-smt-respond-without-interrupt.patch \
	file://1660-prod-tfm-stm32mp-add-ca35_s-agent.patch \
	file://1661-drivers-stm32_tamp-call-stm32_tamp_set_secret_list-a.patch \
	file://1662-drivers-stm32_risaf-alignment-with-upstream.patch \
	file://1663-dt-bindings-add-RISAFSUBPROT-description-for-reserve.patch \
	file://1664-stm32mp2-add-RISAF-device-tree-bindings-for-subregio.patch \
	file://1665-drivers-stm32_risaf-refactor-granularity-getting-fro.patch \
	file://1666-drivers-stm32_risaf-add-subregion-management-support.patch \
	file://1667-drivers-stm32_risaf-add-subregion-support-in-firewal.patch \
	file://1668-drivers-stm32_risaf-refactor-configuration-functions.patch \
	file://1669-dt-bindings-add-MCE-encryption-in-reserved-memories-.patch \
	file://1670-clk-stm32-fix-management-of-set_rate-and-determine_r.patch \
	file://1671-drivers-stm32_i2c-fallback-to-interrupt-access-when-.patch \
	file://1672-plat-stm32mp1-stpmic1-I2C-accesses-under-interrupt.patch \
	file://1673-drivers-stm32mp_pmic2-I2C-accesses-under-interrupt.patch \
	file://1674-drivers-stm32_risaf-fix-clock-support.patch \
	file://1675-drivers-stm32_risaf-fix-HWCFGR-information-managemen.patch \
	file://1676-dts-stm32-fix-GPU-OPP-description.patch \
	file://1677-crypto-stm32-fix-stm32_cryp-CTR-mode-on-small-input-.patch \
	file://1678-crypto-stm32-fix-stm32_saes-CTR-mode-on-small-input-.patch \
	file://1679-dts-stm32-fix-license-of-stm32mp15-boards.patch \
	file://1680-drivers-stm32_rng-update-RNG-support-for-STM32MP2.patch \
	file://1681-libmbedtls-fix-compilation-warning-with-GCC14.patch \
	file://1682-dts-stm32-add-I2C3-SCL-rising-and-falling-time-prope.patch \
	file://1683-core-plat-stm32mp2-enable-CFG_STM32_IRQ_NOTIF.patch \
	file://1684-drivers-stm32_dbgmcu_mbx-feed-AUTH_DEV-register-with.patch \
	file://1685-drivers-stm32_bsec-export-stm32mp2x-debug-defines-in.patch \
	file://1686-drivers-stm32_bsec3-add-debug-control-registers-supp.patch \
	file://1687-drivers-stm32_bsec-add-permissions-mask-parsing-for-.patch \
	file://1688-core-plat-stm32mp2-psa-adac-implement-psa_adac_apply.patch \
	file://1689-driver-stm32_dbgmcu_mbx-check-if-an-IT-is-pending-on.patch \
	file://1690-dts-stm32-stm32mp2-fix-address-conflict-between-SCMI.patch \
	file://1691-dts-stm32-change-scmi-for-CM33-shared-memory-address.patch \
	file://1692-dts-stm32-change-scmi-for-CM33-shared-memory-address.patch \
	file://1693-dts-stm32-change-scmi-for-CM33-shared-memory-address.patch \
	file://1694-plat-stm32mp2-scmi_server-backup-shared-memory-in-ST.patch \
	file://1695-dts-stm32-stm32mp2-add-support-for-STM32MP25xx-DHCOS.patch \
	"
