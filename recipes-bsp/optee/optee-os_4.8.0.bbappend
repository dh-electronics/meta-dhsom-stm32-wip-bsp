FILESEXTRAPATHS:prepend := "${THISDIR}/upports:"

COMPATIBLE_MACHINE:dh-stm32mp23-dhsom = "dh-stm32mp23-dhsom"
OPTEEMACHINE:dh-stm32mp23-dhsom = "stm32mp2-23XX_DHCOS_SOM "
EXTRA_OEMAKE:append:dh-stm32mp23-dhsom = " CFG_EMBED_DTB_SOURCE_FILE=stm32mp23xx-dhcos-som.dts"

COMPATIBLE_MACHINE:dh-stm32mp25-dhsom = "dh-stm32mp25-dhsom"
OPTEEMACHINE:dh-stm32mp25-dhsom = "stm32mp2-25XX_DHCOS_SOM "
EXTRA_OEMAKE:append:dh-stm32mp25-dhsom = " CFG_EMBED_DTB_SOURCE_FILE=stm32mp25xx-dhcos-som.dts"

EXTRA_OEMAKE:append:dh-stm32mp2-dhsom = " CFG_STM32_EARLY_CONSOLE_UART=6"

# Workaround for ST downstream 0004-core-scmi-server-dump-source-files-from-SCP-firmware.patch
# which includes binary blobs in the patch file. OE default patchtool, quilt,
# rejects such bad patches. Work around this by using git to apply the patches.
PATCHTOOL:dh-stm32mp2-dhsom = "git"

DEPENDS:append:dh-stm32mp2-dhsom = " python3-pillow-native"

SRC_URI:append:dh-stm32mp2-dhsom = " \
	file://0001-CONTRIBUTING-add-contributing-guide.patch \
	file://0002-SECURITY-add-security-notice.patch \
	file://0003-core-sm-support-LPAE-in-monitor-context-backup.patch \
	file://0004-mk-config-allow-to-use-lightweight-tags-instead-of-a.patch \
	file://0005-plat-stm32mp1-conf-enable-the-WERROR-check.patch \
	file://0006-plat-stm32mp2-embed-some-extra-test-facilities.patch \
	file://0007-plat-stm32mp1-add-OEM-SMC-default-functions.patch \
	file://0008-plat-stm32mp1-get-DRAM-size-from-embedded-DTB.patch \
	file://0009-plat-stm32mp1-do-not-generate-stm32-files.patch \
	file://0010-plat-stm32mp1-nsec-service-deprecate-scmi-agent-1.patch \
	file://0011-plat-stm32mp1-optimize-xlat-table-allocation.patch \
	file://0012-core-dt-allow-using-_fdt_read_paddr-in-drivers.patch \
	file://0013-plat-stm32mp1-conf-increase-MMAP-regions-number.patch \
	file://0014-makefile-build-ta_dev_kit-but-not-TAs-when-CFG_WITH_.patch \
	file://0015-plat-stm32mp1-do-not-discriminate-how-CFG_TZDRAM_STA.patch \
	file://0016-plat-stm32mp1-add-CFG_STM32MP1_OPTEE_IN_SYSRAM.patch \
	file://0017-core-add-external-device-tree-support.patch \
	file://0018-plat-stm32mp2-add-external-device-tree-support.patch \
	file://0019-plat-stm32mp1-add-external-device-tree-support.patch \
	file://0020-plat-stm32mp1-add-Makefile-target-to-build-all-DTB-f.patch \
	file://0021-plat-stm32mp2-set-unsafe-config-to-keep-performance.patch \
	file://0022-plat-stm32mp1-conf-default-enable-CFG_DT_CACHED_NODE.patch \
	file://0023-plat-stm32mp2-conf-default-enable-CFG_DT_CACHED_NODE.patch \
	file://0024-dt-bindings-import-YAML-documentation-from-kernel-6..patch \
	file://0025-dt-bindings-backport-OP-TEE-specific-documentation.patch \
	file://0026-dt-bindings-cleanup-binding-documentation-for-STM32M.patch \
	file://0027-dt-bindings-dma-add-st-syscfg-arcr-property-to-st-st.patch \
	file://0028-plat-stm32mp1-stm32mp1_pwr-fix-compatible.patch \
	file://0029-dt-bindings-st-stm32-calibration-add-STM32MP25-suppo.patch \
	file://0030-dt-bindings-update-YAML-documentation-for-stm32mp25-.patch \
	file://0031-dt-bindings-pinctrl-stm32mp-flags-for-non-secure-pin.patch \
	file://0032-dt-bindings-scmi-add-scmi-bindings.patch \
	file://0033-dt-bindings-stm32_rng-add-RNG-support-for-STM32MP21.patch \
	file://0034-dt-bindings-scmi-rename-scmi-regulators-by-regulator.patch \
	file://0035-dt-bindings-update-documentation-of-st-stm32-exti.patch \
	file://0036-dt-bindings-add-RISAFSUBPROT-description-for-reserve.patch \
	file://0037-dt-bindings-add-MCE-encryption-in-reserved-memories-.patch \
	file://0038-dt-bindings-update-YAML-documentation-for-fixed-cloc.patch \
	file://0039-core-panic-clean-cache-before-issuing-WFI-instructio.patch \
	file://0040-core-panic-add-missing-inclusion-of-keep.h.patch \
	file://0041-core-mm-print-non-secure-memory-ranges.patch \
	file://0042-checkpatch-discard-line-starting-with-Change-Id.patch \
	file://0043-plat-stm32mp2-increase-heap-to-384kB.patch \
	file://0044-plat-stm32mp2-set-TEE_RAM_VA_SIZE-to-4Mb.patch \
	file://0045-dts-stm32-convert-all-stm32mp15xx.dts-to-use-SCMI.patch \
	file://0046-dts-stm32-add-missing-reset-for-UART-nodes.patch \
	file://0047-dts-stm32-add-support-of-new-stm32mp15-boards.patch \
	file://0048-dts-stm32-add-stgen-node-for-stm32mp15.patch \
	file://0049-plat-stm32mp1-add-OP-TEE-resource-manager-configurat.patch \
	file://0050-plat-stm32mp1-allow-probe-on-non-secure-timers-for-s.patch \
	file://0051-dts-stm32-allocate-RNG1-to-secure-world-for-STM32MP1.patch \
	file://0052-drivers-stm32_i2c-add-support-of-stm32mp2-family.patch \
	file://0053-drivers-stm32_i2c-fallback-to-interrupt-access-when-.patch \
	file://0054-dts-stm32-add-i2c1-to-i2c8-nodes-in-stm32mp251.dtsi.patch \
	file://0055-dts-stm32-add-i2c1-i2c2-i2c7-and-i2c8-nodes-in-stm32.patch \
	file://0056-dts-stm32-add-i2c1-to-i2c3-nodes-in-stm32mp211.dtsi.patch \
	file://0057-core-kernel-update-pm-callback-constraints-to-pageab.patch \
	file://0058-plat-stm32mp2-scmi_server-implement-voltage-domain-p.patch \
	file://0059-plat-stm32mp2-enable-regulator-support.patch \
	file://0060-plat-stm32mp2-default-enable-CFG_DRIVERS_CLOCK_PRINT.patch \
	file://0061-regulator-add-new-ops-init-to-configure-the-driver-c.patch \
	file://0062-drivers-stm32_rifsc-provide-new-API-for-CID-filterin.patch \
	file://0063-plat-stm32mp2-sysconfig-Handle-IO-compensation.patch \
	file://0064-plat-stm32mp2-Add-PWR-driver-for-STM32MP2-family.patch \
	file://0065-plat-stm32mp2-Add-PWR-regulators-driver.patch \
	file://0066-dts-stm32mp21-define-scmi-regulator-consumer.patch \
	file://0067-dts-stm32mp25-define-scmi-regulator-consumer.patch \
	file://0068-dts-stm32-add-PWR-support-on-STM32MP21.patch \
	file://0069-dts-stm32-add-PWR-support-on-STM32MP23.patch \
	file://0070-dts-stm32-add-PWR-support-on-STM32MP25.patch \
	file://0071-plat-stm32mp2-add-support-of-STPMIC2-family.patch \
	file://0072-dts-stm32-add-STPMIC2L-to-stm32mp215f-dk-accessed-wi.patch \
	file://0073-dts-stm32-expose-PWR-regulator-with-SCMI-to-Linux-fo.patch \
	file://0074-dts-stm32-add-STPMIC25-to-stm32mp257f-ev1-accessed-w.patch \
	file://0075-dts-stm32-add-STPMIC25-to-stm32mp257f-dk-accessed-wi.patch \
	file://0076-dts-stm32-expose-regulator-with-SCMI-to-Linux-for-st.patch \
	file://0077-dts-stm32-add-STPMIC25-to-stm32mp235f-dk-accessed-wi.patch \
	file://0078-dts-stm32-expose-PWR-regulator-with-SCMI-to-Linux-fo.patch \
	file://0079-plat-stm32mp2-conf-enable-SCP-SCMI-regulator.patch \
	file://0080-plat-stm32mp1-move-the-initialisation-function-in-th.patch \
	file://0081-drivers-stm32mp15_huk-fix-type-mismatch-in-stm32mp15.patch \
	file://0082-drivers-stm32_bsec-add-define-to-describe-debug-perm.patch \
	file://0083-drivers-stm32_bsec-add-stm32_bsec_self_hosted_debug_.patch \
	file://0084-drivers-stm32_bsec-add-stm32_bsec_read_otp_range_by_.patch \
	file://0085-drivers-stm32_bsec-rework-stm32_bsec_write_debug_con.patch \
	file://0086-drivers-stm32_bsec3-add-BSEC-driver-support.patch \
	file://0087-plat-stm32mp2-conf-support-BSEC3-driver.patch \
	file://0088-plat-stm32mp2-open-the-complete-debug-access-on-STM3.patch \
	file://0089-dts-stm32-add-bsec-node-in-stm32mp251.dtsi.patch \
	file://0090-dts-stm32-add-bsec-node-in-stm32mp231.dtsi.patch \
	file://0091-dts-stm32-add-bsec-node-in-stm32mp211.dtsi.patch \
	file://0092-drivers-stm32mp_provisioning-add-driver-to-manage-sh.patch \
	file://0093-plat-stm32mp2-conf-enable-the-provisioning-driver.patch \
	file://0094-dt-bindings-add-binding-for-the-stm32mp-provisioning.patch \
	file://0095-dts-stm32-add-default-HCONF1-value-for-VDDIO-on-stm3.patch \
	file://0096-dts-stm32-add-default-HCONF1-value-for-VDDIO-on-stm3.patch \
	file://0097-dts-stm32-add-default-HCONF1-value-for-VDDIO-on-stm3.patch \
	file://0098-dts-stm32-add-shadow-provisionning-of-HCONF1-on-stm3.patch \
	file://0099-ta-stm32mp_nvmem-add-provisioning-TA-for-OTP-purpose.patch \
	file://0100-plat-stm32mp1-enable-stm32mp_nvmem-early-TA.patch \
	file://0101-plat-stm32mp2-conf-enable-TA-NVMEM-on-STM32MP2-famil.patch \
	file://0102-plat-stm32mp1-remove-BSEC-SIP-services.patch \
	file://0103-dts-stm32-disable-IWDG1-and-IWDG2-during-low-power-o.patch \
	file://0104-dts-stm32-disable-IWDG1-and-IWDG2-during-low-power-o.patch \
	file://0105-dts-stm32-disable-IWDG1-and-IWDG2-during-low-power-o.patch \
	file://0106-plat-stm32mp1-conf-enable-the-provisioning-driver.patch \
	file://0107-drivers-stm32_gpio-add-support-for-stm32mp21.patch \
	file://0108-drivers-stm32_gpio-use-DECLARE_KEEP_PAGER_PM-macro-f.patch \
	file://0109-drivers-stm32_gpio-register-as-core-service-pm.patch \
	file://0110-drivers-stm32_gpio-panic-on-error-while-applying-RIF.patch \
	file://0111-dts-stm32-remove-unused-pin-definition-for-stm32mp-b.patch \
	file://0112-dts-stm32-add-support-of-usart2-for-stm32mp21.patch \
	file://0113-dts-stm32-add-node-pinctrl-and-pinctrl_z-for-stm32mp.patch \
	file://0114-dts-stm32-add-STM32MP21-pinctrl-DT-file.patch \
	file://0115-dts-stm32-add-GPIO-rif-configuration-for-stm32mp215f.patch \
	file://0116-dts-stm32-add-console-to-stm32mp215f-dk.patch \
	file://0117-TEMP-remove-PMIC-interrupt-management.patch \
	file://0118-drivers-stm32_risaf-differentiate-STM32MP2x-RISAF-im.patch \
	file://0119-dts-stm32-add-RISABx-and-RISABx-nodes-from-STM32MP21.patch \
	file://0120-dts-stm32-add-reserved-memory-for-stm32mp215f-dk.patch \
	file://0121-dts-stm32-add-node-stgen-on-stm32mp21.patch \
	file://0122-drivers-stm32_rng-add-RNG-support-for-STM32MP21.patch \
	file://0123-dts-stm32-add-node-RNG1-and-RNG2-for-stm32mp21.patch \
	file://0124-drivers-gic-register-pm-callbacks.patch \
	file://0125-drivers-gic-restore-GIC-main-config-at-resume.patch \
	file://0126-drivers-gic-API-for-PMR-and-priority-configuration.patch \
	file://0127-drivers-gic-use-GIC_HIGHEST_NS_PRIORITY-macro.patch \
	file://0128-core-gic-use-DECLARE_KEEP_PAGER_PM-for-gic_pm-functi.patch \
	file://0129-drivers-gic-implement-the-possibility-to-acknowledge.patch \
	file://0130-plat-stm32mp1-enable-CFG_ARM_GIC_PM-in-conf.mk.patch \
	file://0131-plat-stm32mp2-enable-GIC-PM-support.patch \
	file://0132-dt-bindings-clock-stm32mp1-add-SCMI-IDs-for-GPIO-ban.patch \
	file://0133-plat-stm32mp1-create-helper-file-for-stm32mp1.patch \
	file://0134-plat-stm32mp1-add-stm32_reset_system-function.patch \
	file://0135-plat-stm32mp1-rcc-header-can-be-included-in-assembly.patch \
	file://0136-drivers-clk-clk-stm32mp15-fix-typo-PMU-MPU.patch \
	file://0137-drivers-clk-clk-stm32mp15-add-stm32mp_rcc_clk_to_clo.patch \
	file://0138-drivers-clk-stm32mp15-fix-incorrect-pll-dt-parsing.patch \
	file://0139-drivers-clk-stm32mp15-force-clk_op_compute_rate-in-u.patch \
	file://0140-plat-stm32mp1-enable-fixed-clock-in-stm32mp15.patch \
	file://0141-drivers-clk-add-clock-PM-callback-in-clk-stm32mp15.c.patch \
	file://0142-stm32mp15-tree-wide-use-DECLARE_KEEP_PAGER_PM-for-MP.patch \
	file://0143-clk-stm32mp1-add-dsb-in-clock-driver.patch \
	file://0144-clk-stm32mp1_rcc-remove-unused-defines.patch \
	file://0145-drivers-clk-smt32mp15-stm32mp1_clk_on-is-local.patch \
	file://0146-dt-bindings-stm32-add-stm32mp1-clksrc.h-bindings.patch \
	file://0147-drivers-clk-stm32mp15-apply-full-clock-tree-in-OP-TE.patch \
	file://0148-drivers-clk-stm32mp15-add-the-operating-point-suppor.patch \
	file://0149-clk-cpu_opp-provide-the-OPP-node-to-STM32MP15-RCC-dr.patch \
	file://0150-clk-stm32mp15-debug-add-display-of-all-DT-config-of-.patch \
	file://0151-clk-add-is_enabled-ops.patch \
	file://0152-drivers-clk-stm32mp15-add-is_enabled-ops.patch \
	file://0153-clk-stm32mp13-implement-is_enabled-clock-ops.patch \
	file://0154-clk-stm32mp13-removal-of-LSE-clock-on-RNG-clock-swit.patch \
	file://0155-clk-stm32mp13-do-not-reconfigure-LSE.patch \
	file://0156-clk-stm32mp13-fix-of-CKPER-clock-disabling.patch \
	file://0157-clk-stm32mp13-remove-the-iwdg1-from-the-critical-clo.patch \
	file://0158-plat-stm32mp1-default-enable-CFG_DRIVERS_-_PRINT_TRE.patch \
	file://0159-clk-stm32mp13-fix-stm32mp13_clk_probe-3498-Failed-to.patch \
	file://0160-clk-stm32mp13-add-round-rate.patch \
	file://0161-clk-stm32mp13-use-determine_rate-for-OPP.patch \
	file://0162-clk-stm32mp13-add-power-management.patch \
	file://0163-drivers-clk-stm32mp13-test-stm32_gate_rdy_disable-re.patch \
	file://0164-clk-stm32mp13-check-sprintf-return-value.patch \
	file://0165-clk-stm32mp13-debug-add-display-of-all-DT-config-of-.patch \
	file://0166-clk-stm32-add-support-of-pinctrl-and-clock-for-RCC-n.patch \
	file://0167-clk-stm32mp1-add-support-of-pinctrl-and-clock-for-RC.patch \
	file://0168-drivers-clk-stm32mp1-fix-clear_rcc_reset_status.patch \
	file://0169-drivers-clk-stm32mp13-simplify-stm32_clock_pm.patch \
	file://0170-clk-stm32mp13-fix-gate-of-ck_ddrphycapb-clock.patch \
	file://0171-plat-stm32mp1-enumerate-clocks-by-arrays-where-appli.patch \
	file://0172-clk-stm32mp13-don-t-gate-ungate-an-oscillator-if-it-.patch \
	file://0173-clk-stm32mp13-add-critical-clock-flag-from-common-cl.patch \
	file://0174-clk-stm32mp25-fix-FLEXGEN-configuration-of-pred-divi.patch \
	file://0175-dt-bindings-remove-CLK_CFG-CMD_CLK-support-for-st-ke.patch \
	file://0176-clk-stm32mp25-rename-RCC_USBTCCFGR-register-into-RCC.patch \
	file://0177-drivers-stm32_rif-add-mask-to-get-static-CID-of-a-pe.patch \
	file://0178-clk-stm32mp25-enable-safe-reset-feature-systematical.patch \
	file://0179-clk-stm32mp21-enable-safe-reset-feature-systematical.patch \
	file://0180-dt-bindings-clock-stm32mp25-add-IDs-of-Cortex-CM0-C3.patch \
	file://0181-clk-clk-stm32mp25-fix-HSI-HSE-MSI-Kernel-clocks.patch \
	file://0182-clk-stm32mp25-make-RIF-configuration-not-mandatory.patch \
	file://0183-clk-stm32mp21-Check-Peripheral-RIF-assignation-befor.patch \
	file://0184-clk-stm32mp2-add-support-of-pinctrl-and-clock-for-RC.patch \
	file://0185-clk-stm32mp25-remove-support-of-st-clksrc.patch \
	file://0186-plat-stm32mp2-enumerate-clocks-by-arrays-where-appli.patch \
	file://0187-clk-stm32mp25-add-management-of-autonomous-clocks.patch \
	file://0188-dt-bindings-clock-expose-PCIE-bus-clock-as-an-SCMI-c.patch \
	file://0189-clk-stm32mp25-add-management-of-GPU-OPPs.patch \
	file://0190-clk-stm32mp25-debug-add-display-of-all-DT-config-of-.patch \
	file://0191-clk-stm32mp21-debug-add-display-of-all-DT-config-of-.patch \
	file://0192-clk-stm32-fix-management-of-set_rate-and-determine_r.patch \
	file://0193-clk-stm32mp25-add-support-of-CPU1-set-parent.patch \
	file://0194-clk-stm32mp21-add-support-of-CPU1-set-parent.patch \
	file://0195-clk-stm32mp21-configure-STGEN-flexgen-in-.enable-ops.patch \
	file://0196-clk-stm32mp25-configure-STGEN-flexgen-in-.enable-ops.patch \
	file://0197-clk-stm32mp21-add-clock-dependency-from-BSEC-DENR.patch \
	file://0198-clk-stm32mp25-implement-is_enabled-clock-ops.patch \
	file://0199-clk-stm32mp21-implement-is_enabled-clock-ops.patch \
	file://0200-clk-stm32mp25-restore-RCC-driver-after-a-standby.patch \
	file://0201-clk-stm32mp21-add-critical-clock-flag-from-common-cl.patch \
	file://0202-clk-stm32mp25-add-critical-clock-flag-from-common-cl.patch \
	file://0203-clk-stm32-enable-new-critical-clock-management.patch \
	file://0204-clk-stm32-implement-disable-unused-clock.patch \
	file://0205-clk-stm32mp25-add-round-rate-for-flexgen.patch \
	file://0206-clk-stm32mp21-add-round-rate-for-flexgen.patch \
	file://0207-clk-stm32mp25-align-RCC-TDCID-ownership-and-protecti.patch \
	file://0208-clk-stm32mp25-align-RCC-TDCID-ownership-and-protecti.patch \
	file://0209-drivers-clk-don-t-mix-error-codes-in-stm32mp25-drive.patch \
	file://0210-drivers-clk-don-t-mix-error-codes-in-stm32mp21-drive.patch \
	file://0211-clk-add-round-rate-ops.patch \
	file://0212-clk-add-determine-rate-ops.patch \
	file://0213-drivers-clk-use-ops-determine_rate-in-clk_round_rate.patch \
	file://0214-drivers-clk-add-functions-to-save-restore-clock-cont.patch \
	file://0215-clk-add-clk_reparent-function.patch \
	file://0216-clk-error-when-set_rate-ops-is-not-supported.patch \
	file://0217-drivers-clk-change-tree-trace-level.patch \
	file://0218-clk-add-CLK_IS_CRITICAL-flag-handling.patch \
	file://0219-clk-add-support-for-disabling-unused-clocks.patch \
	file://0220-plat-stm32mp1-scmi-server-expose-GPIO-bank-clocks-th.patch \
	file://0221-plat-stm32mp1-remove-SCP-firmware-support.patch \
	file://0222-drivers-scmi-msg-implement-duty-cycle-ops-with-SCMI-.patch \
	file://0223-drivers-scmi-msg-round-rate.patch \
	file://0224-drivers-scmi-msg-introduce-SCMI-regulator-consumer.patch \
	file://0225-drivers-scmi-msg-specific-OSTLv4-v5-duty-cycle-round.patch \
	file://0226-plat-stm32mp1-scmi-clock-duty-cycle.patch \
	file://0227-plat-stm32mp1-scmi-fix-supported-clock-rate.patch \
	file://0228-plat-stm32mp1-scmi-add-the-power-management-in-serve.patch \
	file://0229-plat-stm32mp1-scmi-fix-assert-after-low-power.patch \
	file://0230-plat-stm32mp1-scmi-rely-on-regulator-consumer-for-vo.patch \
	file://0231-plat-stm32mp1-scmi-simplify-find_-for-deterministic-.patch \
	file://0232-plat-stm32mp1-enumerate-clocks-by-arrays-where-appli.patch \
	file://0233-plat-stm32mp1-don-t-register-scmi-server-PM-if-not-n.patch \
	file://0234-plat-stm32mp1-scmi_server-use-DECLARE_KEEP_PAGER_PM.patch \
	file://0235-plat-stm32mp1-enable-SCMI-regulator-consumer-for-STM.patch \
	file://0236-drivers-regulator-update-vrefbuf-driver-for-STM32MP2.patch \
	file://0237-dts-stm32-add-VREFBUF-node-in-stm32mp251.dtsi.patch \
	file://0238-dts-stm32-add-VREFBUF-node-in-stm32mp231.dtsi.patch \
	file://0239-dts-stm32-add-VREFBUF-node-in-stm32mp211.dtsi.patch \
	file://0240-plat-stm32mp2-conf-enable-VREFBUF.patch \
	file://0241-drivers-regulator-use-DECLARE_KEEP_PAGER_PM.patch \
	file://0242-dts-stm32mp13-Define-scmi-regulator-consumers.patch \
	file://0243-core-dt-bindings-stm32mp15-update-IDs-for-SCMI-volta.patch \
	file://0244-drivers-regulator-get-supply-voltages-as-fallback.patch \
	file://0245-drivers-regulator-get-supply-voltages-from-supply-in.patch \
	file://0246-drivers-regulator-avoid-to-restore-iod-supply-on-stm.patch \
	file://0247-plat-stm32mp2-Add-all_dtbs-build-target.patch \
	file://0248-plat-stm32mp2-adapt-SRAM1-mapping-for-M33-TDCID.patch \
	file://0249-plat-stm32mp2-conf-add-CFG_STM32_CM33TDCID.patch \
	file://0250-dts-stm32-add-IOM-EVAL-pins-muxing-configurations-fo.patch \
	file://0251-core-scmi-server-dump-source-files-from-SCP-firmware.patch \
	file://0252-product-optee-compile-voltd_regulator-module.patch \
	file://0253-product-optee-stm32mp2-add-voltage-domain.patch \
	file://0254-core-scmi-server-build-in-tree-SCP-firmware-source-f.patch \
	file://0255-core-lib-scmi-server-add-log-prefix-support-for-SCP-.patch \
	file://0256-core-lib-scmi-server-update-displayed-SCP-Firmware-v.patch \
	file://0257-drivers-stm32_exti-prevent-double-save-restore-of-EX.patch \
	file://0258-drivers-stm32_exti-fix-interrupt-handler-regarding-p.patch \
	file://0259-drivers-stm32_exti-fix-check-access-with-RIF-for-M33.patch \
	file://0260-drivers-stm32_exti-fix-potential-NULL-pointer-derefe.patch \
	file://0261-dts-stm32-use-correct-SPI-for-parent-of-EXTI-19-for-.patch \
	file://0262-dts-stm32-use-correct-SPI-for-parent-of-EXTI-19-for-.patch \
	file://0263-dts-stm32-add-exti1-and-exti2-for-stm32mp211.patch \
	file://0264-dts-stm32-add-rif-configuration-for-exti-for-stm32mp.patch \
	file://0265-dts-stm32-align-stm33mp257f-DK-exti2-with-stm32mp257.patch \
	file://0266-dts-stm32-align-stm33mp235f-DK-RIF-with-stm32mp257f-.patch \
	file://0267-dt-bindings-add-PWR-dt-bindings.patch \
	file://0268-dts-stm32mp15-align-reserved-memory-definitions-with.patch \
	file://0269-plat-stm32mp1-conf-move-definitions.patch \
	file://0270-pta-scmi-ocall2-threaded-context.patch \
	file://0271-pta-scmi-support-Ocall2-on-MSG-channel.patch \
	file://0272-pta-scmi-support-OCall-with-SCP-firmware.patch \
	file://0273-core-kernel-ensure-RPC-argument-mobj-on-Ocall-contex.patch \
	file://0274-pta-scmi-fix-OCALL-trace-messages.patch \
	file://0275-core-tee-non-secure-PM_NOIRQ-invocation.patch \
	file://0276-pta-scmi-non-secure-PM_NOIRQ-OCALL-context.patch \
	file://0277-drivers-stm32_iwdg-use-DECLARE_KEEP_PAGER_PM.patch \
	file://0278-dts-stm32mp15-describe-clock-tree-configuration.patch \
	file://0279-plat-stm32mp2-use-software-PRNG-when-CFG_STM32_CM33T.patch \
	file://0280-plat-stm32mp2-update-SRAM1-base-address-for-STM32MP2.patch \
	file://0281-plat-stm32mp1-SiP-SMC-service-for-PWR-access.patch \
	file://0282-dts-stm32-add-the-etzpc-configuration-table-for-boar.patch \
	file://0283-core-arm-psci-implement-PSCI_SET_SUSPEND_MODE-comman.patch \
	file://0284-core-arm-psci-define-psci_set_system_suspend_mode-we.patch \
	file://0285-core-arm-pageable-PM-sequences.patch \
	file://0286-core-kernel-consider-thread-PM-context-in-PM-aware-m.patch \
	file://0287-stm32mp15-tree-wide-use-DECLARE_KEEP_PAGER_PM.patch \
	file://0288-drivers-stm32_saes-add-STM32MP21-support-for-SAES.patch \
	file://0289-plat-stm32mp1-conf-disable-compilation-of-PKA-and-SA.patch \
	file://0290-drivers-crypto-remove-192bits-key-software-fallback-.patch \
	file://0291-plat-stm32mp2-conf-enable-SAES-for-stm32mp2-platform.patch \
	file://0292-plat-stm32mp2-conf-enable-HASH-for-stm32mp2-platform.patch \
	file://0293-plat-stm32mp2-conf-enable-PKA-for-stm32mp2-platforms.patch \
	file://0294-plat-stm32mp2-conf-enable-CRYP-for-stm32mp2-platform.patch \
	file://0295-plat-stm32mp2-add-management-of-SAES-software-fallba.patch \
	file://0296-dts-stm32-configure-etzpc-controller-for-CRYP1-node.patch \
	file://0297-dts-st-add-support-of-CRYP-in-stm32mp21xc.dtsi.patch \
	file://0298-dts-st-define-saes-node-in-stm32mp21xc.dtsi.patch \
	file://0299-dts-st-define-pka-node-in-stm32mp21xc.dtsi.patch \
	file://0300-dts-st-add-support-of-HASH-in-stm32mp211.dtsi.patch \
	file://0301-dts-st-define-hash-node-in-stm32mp231.dtsi.patch \
	file://0302-dts-st-add-support-of-CRYP-in-stm32mp23xc.dtsi.patch \
	file://0303-dts-st-define-saes-node-in-stm32mp23xc.dtsi.patch \
	file://0304-dts-st-define-pka-node-in-stm32mp23xc.dtsi.patch \
	file://0305-dts-st-define-hash-node-in-stm32mp251.dtsi.patch \
	file://0306-dts-st-add-support-of-CRYP-in-stm32mp25xc.dtsi.patch \
	file://0307-dts-st-define-saes-node-in-stm32mp25xc.dtsi.patch \
	file://0308-dts-st-define-pka-node-in-stm32mp25xc.dtsi.patch \
	file://0309-dts-stm32-enable-HASH-on-stm32mp215f-dk.patch \
	file://0310-dts-stm32-enable-PKA-on-stm32mp215f-dk.patch \
	file://0311-dts-stm32-enable-SAES-on-stm32mp215f-dk.patch \
	file://0312-dts-stm32-enable-HASH-on-stm32mp235f-dk.patch \
	file://0313-dts-stm32-enable-PKA-on-stm32mp235f-dk.patch \
	file://0314-dts-stm32-enable-SAES-on-stm32mp235f-dk.patch \
	file://0315-dts-stm32-include-stm32mp25xc.dtsi-in-stm32mp25xf.dt.patch \
	file://0316-dts-stm32-enable-HASH-on-stm32mp257f-dk.patch \
	file://0317-dts-stm32-enable-PKA-on-stm32mp257f-dk.patch \
	file://0318-dts-stm32-enable-SAES-on-stm32mp257f-dk.patch \
	file://0319-dts-stm32-enable-HASH-on-stm32mp257f-ev1.patch \
	file://0320-dts-stm32-enable-PKA-on-stm32mp257f-ev1.patch \
	file://0321-dts-stm32-enable-SAES-on-stm32mp257f-ev1.patch \
	file://0322-core-firewall-add-alternate-configuration-API.patch \
	file://0323-core-firewall-add-memory-range-firewall-controller-o.patch \
	file://0324-core-dt-export-add_probe_node_by_compat-function.patch \
	file://0325-core-dt_driver-add-dt_driver_count_devices.patch \
	file://0326-drivers-stm32_omm-use-firewall-alternate-configurati.patch \
	file://0327-drivers-stm32_rif-Check-availability-before-taking-a.patch \
	file://0328-drivers-stm32_iac-don-t-panic-on-unlegit-IAC.patch \
	file://0329-drivers-stm32_serc-disable-SERC-during-suspend-seque.patch \
	file://0330-dts-stm32-add-firewall-alternate-conf-property-for-o.patch \
	file://0331-dts-stm32-add-SERC-node-in-stm32mp211.dtsi.patch \
	file://0332-dts-stm32-add-node-fmc-in-stm32mp211.dtsi.patch \
	file://0333-dts-stm32-add-RIF-configuration-for-FMC-nodes-on-stm.patch \
	file://0334-plat-stm32mp1-conf-disable-TA-compression-and-reduce.patch \
	file://0335-Squashed-commit-upgrading-to-mbedtls-3.6.5.patch \
	file://0336-plat-stm32mp1-print-configuration-profile.patch \
	file://0337-plat-stm32mp2-print-configuration-profile.patch \
	file://0338-dts-stm32-add-SCMI-HSI-HSE-MSI-Kernel-clocks-for-stm.patch \
	file://0339-dts-stm32-add-SCMI-autonomous-clock-management-for-s.patch \
	file://0340-core-arm-add-OSTLv5-legacy-ARM-SMC-watchdog-0xb20000.patch \
	file://0341-dts-stm32-add-SCMI-HSI-HSE-MSI-Kernel-clocks-for-stm.patch \
	file://0342-plat-stm32mp2-add-OP-TEE-resource-manager-configurat.patch \
	file://0343-plat-stm32mp2-conf-enable-TA-PKCS11.patch \
	file://0344-plat-stm32mp1-conf-enable-TA-PKCS11.patch \
	file://0345-core-add-a-feature-to-store-logs-in-RAM.patch \
	file://0346-drivers-stm32_uart-configure-UART-baudrate-register.patch \
	file://0347-plat-stm32mp1-remove-init-console-from-DTB.patch \
	file://0348-plat-stm32mp2-remove-init-console-from-DTB.patch \
	file://0349-drivers-stm32_uart-Make-UART-init-from-dt-only-durin.patch \
	file://0350-drivers-stm32_uart-add-support-for-resume-and-suspen.patch \
	file://0351-drivers-stm32_uart-handle-clock-disable-during-PM.patch \
	file://0352-drivers-stm32_uart-wait-TC-bit-during-console-flush.patch \
	file://0353-dts-stm32-add-support-of-UART-and-USART-on-stm32mp21.patch \
	file://0354-dts-stm32-add-support-of-UART-and-USART-on-stm32mp23.patch \
	file://0355-dts-stm32-add-support-of-UART-and-USART-on-stm32mp25.patch \
	file://0356-drivers-clk-stm32mp15-use-CFG_STM32MP_OPP_COUNT-to-d.patch \
	file://0357-drivers-stm32_cpu_opp-add-support-of-STM32MP15-for-c.patch \
	file://0358-plat-stm32mp1-enable-CPU-opp-for-STM32MP15.patch \
	file://0359-plat-stm32mp1-conf-set-1ms-for-OPP-latency-on-STM32M.patch \
	file://0360-plat-stm32mp1-conf-enable-scmi-perf-for-STM32MP15.patch \
	file://0361-dts-stm32mp15-add-operating-point-nodes-and-configur.patch \
	file://0362-dts-stm32mp15-describe-cpu-power-supply-on-stm32mp15.patch \
	file://0363-drivers-stm32_risaf-add-a-check-for-region-encryptio.patch \
	file://0364-stm32mp2-add-RISAF-device-tree-bindings-for-subregio.patch \
	file://0365-drivers-stm32_risaf-refactor-granularity-getting-fro.patch \
	file://0366-drivers-stm32_risaf-add-subregion-management-support.patch \
	file://0367-drivers-stm32_risaf-add-subregion-support-in-firewal.patch \
	file://0368-drivers-stm32_risaf-refactor-configuration-functions.patch \
	file://0369-drivers-stm32_risaf-fix-clock-support.patch \
	file://0370-drivers-stm32_risaf-fix-HWCFGR-information-managemen.patch \
	file://0371-drivers-stm32_risaf-add-non-TDCID-treatment.patch \
	file://0372-drivers-stm32_risaf-do-not-enable-disable-clock-on-u.patch \
	file://0373-drivers-stm32_risaf-fix-STM32MP2x-RISAF-region-imple.patch \
	file://0374-plat-stm32mp2-handle-RISAB-and-RISAF-illegal-access-.patch \
	file://0375-dts-stm32-stm32mp2-fix-address-conflict-between-SCMI.patch \
	file://0376-drivers-scmi-msg-initialize-status-for-unused-clock-.patch \
	file://0377-core-kernel-trace_ext-add-printf-function.patch \
	file://0378-lib-libmbedtls-fix-warning-redundant-decls-in-mbedtl.patch \
	file://0379-core-psa-adac-dump-source-files-from-PSA-ADAC-git-tr.patch \
	file://0380-core-psa-adac-remove-unused-files-and-directories.patch \
	file://0381-core-plat-stm32mp2-put-lib-psa-adac-target-stuff-in-.patch \
	file://0382-core-psa-adac-add-skeleton-code-for-psa-adac-crypto-.patch \
	file://0383-core-psa-adac-fix-adac-crypto.c-compilation.patch \
	file://0384-core-psa-adac-fix-PSA_ADAC_LOG_-T-DUMP-with-snprintf.patch \
	file://0385-core-psa-adac-fix-compilation-issue-due-to-static_bu.patch \
	file://0386-core-psa-adac-make-it-buildable-as-library-for-optee.patch \
	file://0387-core-plat-stm32mp2-enable-CFG_PSA_ADAC-on-stm32mp21.patch \
	file://0388-drivers-add-driver-for-DBGMCU-secure-debug-mailbox-f.patch \
	file://0389-core-plat-stm32mp2-psa-adac-implement-crypto-api.patch \
	file://0390-core-plat-stm32mp2-psa-adac-implement-transport-laye.patch \
	file://0391-core-plat-stm32mp2-retrieve-chip-device-id-from-sysc.patch \
	file://0392-core-plat-stm32mp2-psa-adac-implement-platform-api.patch \
	file://0393-drivers-stm32_dbgmcu_mbx-manage-secure-debug-request.patch \
	file://0394-dts-stm32-add-DBGMCU-secure-debug-mailbox-on-stm32mp.patch \
	file://0395-drivers-add-counter-framework.patch \
	file://0396-drivers-add-stm32-lptimer.patch \
	file://0397-drivers-add-stm32-timer.patch \
	file://0398-dts-st-fix-timers-and-lptimers-node-in-stm32mp131.patch \
	file://0399-dts-stm32-add-subnode-counter-for-timers15-in-stm32m.patch \
	file://0400-dts-stm32-add-low-power-timer-nodes-on-stm32mp211.patch \
	file://0401-dts-stm32-add-low-power-timer-nodes-on-stm32mp231.patch \
	file://0402-dts-stm32-add-lptimer-nodes-in-stm32mp251.dtsi.patch \
	file://0403-plat-stm32mp1-conf-enable-timers-and-lptimer-drivers.patch \
	file://0404-plat-stm32mp2-conf-enable-lptimer-driver.patch \
	file://0405-drivers-stm32_rng-fix-RNG-conditional-reset-behavior.patch \
	file://0406-drivers-stm32_rng-fix-configuration-field-definition.patch \
	file://0407-drivers-stm32_rng-manage-RNG-customization-with-devi.patch \
	file://0408-drivers-stm32_rng-add-a-PSA-call-in-M33TD-CID-config.patch \
	file://0409-drivers-stm32_rng-update-RNG-support-for-STM32MP2.patch \
	file://0410-stm32-rng-clarify-error-codes-in-RNG-driver.patch \
	file://0411-drivers-stm32_rng-keep-random-generation-on-when-opt.patch \
	file://0412-core-add-CFG_WITH_TRNG-y-n-to-allow-building-without.patch \
	file://0413-core-crypto-rng_hw-register-unregister-TRNG.patch \
	file://0414-core-rng_support-helper-function-to-register-TRNG.patch \
	file://0415-core-drivers-TRNG-driver-register-their-devices.patch \
	file://0416-dt-bindings-dma-align-st-stm32-dma3.yaml-with-v6.18-.patch \
	file://0417-plat-stm32mp2-add-HPDMA-SYSCFG-support.patch \
	file://0418-drivers-stm32_hpdma-add-Address-Remapping-configurat.patch \
	file://0419-dts-stm32-update-hpdma-nodes-in-stm32mp251.dtsi.patch \
	file://0420-dts-stm32-update-hpdma-nodes-in-stm32mp231.dtsi.patch \
	file://0421-dts-stm32-add-HPDMA1-2-3-nodes-in-stm32mp211.dtsi.patch \
	file://0422-dts-stm32-add-RIF-configuration-for-HPDMA-on-stm32mp.patch \
	file://0423-dts-stm32-enable-HPDMA-on-stm32mp215f-dk.patch \
	file://0424-core-drivers-add-mailbox-framework.patch \
	file://0425-core-pta-add-optee-mailbox-framework-test.patch \
	file://0426-drivers-stm32_ipcc-add-mailbox-support.patch \
	file://0427-core-drivers-mailbox-add-device-capabilities.patch \
	file://0428-drivers-stm32_ipcc-add-capabilities-ops-provided-by-.patch \
	file://0429-plat-stm32mp2-add-mailbox-driver-support.patch \
	file://0430-core-pta-add-optee-mailbox-user-for-test.patch \
	file://0431-libmbedtls-Fix-missing-ctx_clone_func-in-xts_aes_inf.patch \
	file://0432-core-lib-add-rse_comms.patch \
	file://0433-plat-stm32mp2-add-psa-support-on-rse_comms.patch \
	file://0434-dts-stm32mp2-add-ipcc1-for-soc-stm32mp211.patch \
	file://0435-dts-stm32mp2-add-ipcc1-rif-config-on-stm32mp21.patch \
	file://0436-drivers-stm32_lptimer-clock-enable-timer-in-probe-se.patch \
	file://0437-core-pta-ask-for-enumeration.patch \
	file://0438-core-pta-HWRNG-enumerate-upon-registration.patch \
	file://0439-core-pta-RTC-enumerates-upon-RTC-registration.patch \
	file://0440-dts-stm32-add-RTC-node-in-stm32mp211.dtsi.patch \
	file://0441-dts-stm32-add-RIF-config-for-RTC-on-stm32mp215f-dk.patch \
	file://0442-plat-stm32mp2-add-tamper-masking-in-SYSCFG-support.patch \
	file://0443-plat-stm32mp1-add-a-function-to-enable-monitoring-in.patch \
	file://0444-plat-stm32mp2-add-a-function-to-enable-monitoring-in.patch \
	file://0445-drivers-stm32_tamp-allow-subnode-to-be-probed.patch \
	file://0446-drivers-stm32_tamp-add-support-for-masking-potential.patch \
	file://0447-drivers-stm32_tamp-enable-monitoring-in-PWR-for-asso.patch \
	file://0448-drivers-stm32_tamp-handle-LSE-monitoring-tamper.patch \
	file://0449-drivers-stm32_tamp-call-stm32_tamp_set_secret_list-a.patch \
	file://0450-drivers-stm32_tamp-drain-pending-events-before-IRQ-e.patch \
	file://0451-drivers-stm32_tamp-remove-duplicated-PRIVCFGR-macros.patch \
	file://0452-drivers-stm32_tamp-validate-OUT_TAMP-id-from-DT.patch \
	file://0453-dts-stm32-add-stm32mp21-TAMP-node.patch \
	file://0454-dts-stm32-add-TAMP-RIF-configuration-for-stm32mp215f.patch \
	file://0455-dts-stm32-add-nvram-NVMEM-node-under-tamp-in-stm32mp.patch \
	file://0456-dts-stm32-declare-the-reboot-modes-in-stm32mp251.dts.patch \
	file://0457-drivers-nvmem-add-write-API-for-nvmem-controllers.patch \
	file://0458-drivers-nvmem-stm32_tamp_nvram-add-TAMP-Backup-regis.patch \
	file://0459-plat-stm32mp2-conf-enable-nvmem-support-for-TAMP-Bac.patch \
	file://0460-plat-stm32mp1-conf-enable-nvmem-support-for-TAMP-Bac.patch \
	file://0461-dts-stm32-add-nvram-NVMEM-node-under-tamp-in-stm32mp.patch \
	file://0462-dts-stm32-declare-the-reboot-modes-in-stm32mp131.dts.patch \
	file://0463-dts-stm32-add-nvram-NVMEM-node-under-tamp-in-stm32mp.patch \
	file://0464-dts-stm32-add-reboot-mode-in-stm32mp151.dtsi.patch \
	file://0465-dts-stm32-add-nvram-NVMEM-node-under-tamp-in-stm32mp.patch \
	file://0466-pta-stm32mp-add-debug-access-PTA.patch \
	file://0467-plat-stm32mp1-default-enable-CFG_STM32_DEBUG_ACCESS_.patch \
	file://0468-pta-stm32mp-debug-allow-use-with-BSEC3.patch \
	file://0469-plat-stm32mp2-default-enable-CFG_STM32_DEBUG_ACCESS_.patch \
	file://0470-clk-stm32mp25-add-helper-to-query-DDRPERFM-access-fr.patch \
	file://0471-clk-stm32mp1-add-dummy-helper-to-query-DDRPERFM-acce.patch \
	file://0472-pta-stm32mp-debug-add-handling-for-DDRPERFM.patch \
	file://0473-dts-stm32-remove-unsupported-field-regulator-initial.patch \
	file://0474-dts-stm32mp15-harden-RCC-secure-configuration-on-ST-.patch \
	file://0475-core-pta-stm32-add-stm32-clock-calibration-service.patch \
	file://0476-plat-stm32mp1-add-calibration-driver-for-STM32MP1-pl.patch \
	file://0477-clk-stm32mp2-add-clock-calibration-for-HSI-MSI-clock.patch \
	file://0478-clk-stm32mp21-fix-clock-calibration-for-HSI-MSI-cloc.patch \
	file://0479-clk-stm32-create-a-dedicated-sub-directory-for-STM32.patch \
	file://0480-clk-stm32mp1-move-clock-calibration-to-stm32-clock-d.patch \
	file://0481-plat-stm32mp1-conf-enable-HSI-CSI-clock-calibration.patch \
	file://0482-plat-stm32mp2-conf-enable-HSI-MSI-clock-calibration.patch \
	file://0483-dts-stm32mp1-add-the-calibration-node.patch \
	file://0484-dts-stm32mp21-add-the-calibration-node-on-STM32MP21.patch \
	file://0485-dts-stm32-add-HSI-CSI-calibration-on-STM32MP135F-DK.patch \
	file://0486-dts-stm32-add-HSI-CSI-calibration-on-STM32MP15x-boar.patch \
	file://0487-dts-stm32-activate-HSI-calibration-on-STM32MP25-boar.patch \
	file://0488-dts-stm32-activate-HSI-calibration-on-STM32MP23-boar.patch \
	file://0489-dts-stm32-activate-HSI-calibration-on-STM32MP215f-dk.patch \
	file://0490-clk-stm32-add-hse-clock-monitoring-feature.patch \
	file://0491-clk-stm32-add-suspend-resume-callback-for-HSE-monito.patch \
	file://0492-plat-stm32mp1-conf-add-hse-monitoring-support-on-STM.patch \
	file://0493-plat-stm32mp2-conf-add-hse-monitoring-support-on-STM.patch \
	file://0494-dts-stm32mp13-add-HSE-monitor-clocks.patch \
	file://0495-dts-activate-lptimer3-for-stm32mp135-disco-boards.patch \
	file://0496-dts-stm32-enable-hse-monitoring-for-stm32mp135f-dk-b.patch \
	file://0497-dts-stm32-add-frequency-monitor-to-STM32MP2-SoC-file.patch \
	file://0498-dts-stm32mp151-add-address-cells-size-cells-in-rcc-n.patch \
	file://0499-plat-stm32mp2-add-stm32mp2_tamp-driver.patch \
	file://0500-drivers-stm32_ipcc-restore-control-and-mask-register.patch \
	file://0501-drivers-stm32_cpu_opp-update-cpu-opp-for-STM32MP1.patch \
	file://0502-dts-stm32-add-CPU-opp-for-STM32MP25.patch \
	file://0503-dts-stm32-add-CPU-OPP-description-in-STPM32P23.patch \
	file://0504-dts-stm32-add-CPU-OPP-description-in-STPM32P21.patch \
	file://0505-dt-bindings-soc-stm32-describe-GPU.patch \
	file://0506-dts-stm32-add-GPU-OPP-description-in-STM32MP25.patch \
	file://0507-dts-stm32-add-GPU-OPP-description-in-STM32MP23.patch \
	file://0508-dts-stm32-describe-opp-configuration-for-STM32MP2-bo.patch \
	file://0509-plat-stm32mp2-sysconf-add-new-defines-for-CA35SS-reg.patch \
	file://0510-drivers-stm32_cpu_opp-add-STM32MP2-support.patch \
	file://0511-drivers-stm32_cpu_opp-introduce-GPU-OPP-driver-for-S.patch \
	file://0512-plat-stm32mp2-enable-CFG_STM32_CPU_OPP-and-CFG_STM32.patch \
	file://0513-dt-bindings-add-stm32mp25-power-bindings.patch \
	file://0514-core-notif-fix-assert-if-atomic_cb-is-null.patch \
	file://0515-core-lib-scmi-server-remove-support-of-stm32mp1x.patch \
	file://0516-scmi-server-disable-CFG_SCPFW_MOD_OPTEE_VOLTD_REGULA.patch \
	file://0517-scmi-server-info-is-the-maximal-log-level-for-STMP32.patch \
	file://0518-plat-stm32mp2-scmi_server-implement-dvfs-protocol.patch \
	file://0519-plat-stm32mp2-scmi_server-implement-power-domain-pro.patch \
	file://0520-plat-stm32mp2-scmi-add-mailbox-support-for-cortexm.patch \
	file://0521-plat-stm32mp2-add-GPU-to-probe-bus-RIF-exceptions.patch \
	file://0522-dts-stm32-declare-ipcc1-as-mbox-provider-on-stm32mp2.patch \
	file://0523-dts-stm32-declare-ipcc1-as-mbox-provider-on-stm32mp2.patch \
	file://0524-dts-stm32-describe-scmi-resources-for-stm32mp25x.patch \
	file://0525-dts-stm32-describe-scmi-resources-for-stm32mp23x.patch \
	file://0526-dts-stm32-describe-scmi-resources-for-stm32mp21x.patch \
	file://0527-core-add-quiet-option.patch \
	file://0528-mod-clock-remove-const-containts-in-module-configura.patch \
	file://0529-mod-voltage_domain-remove-const-attribute-from-confi.patch \
	file://0530-mod-optee-clock-get-rates-in-continous-description.patch \
	file://0531-mod-wide-scmi-clock-duty-cycle-support.patch \
	file://0532-mod-scmi_clock-handle-SCMI_DENIED-in-set_request_res.patch \
	file://0533-mod-optee-clock-get-min-max-clock-from-list-bounds.patch \
	file://0534-mod-scmi_voltage_domain-fix-scmi_api-respond-size.patch \
	file://0535-mod-scmi_voltage_domain-validate-element_id.patch \
	file://0536-mod-dvfs-call-set_rate-when-frequency-change-with-sa.patch \
	file://0537-arch-optee-helper-function-to-convert-TEE_Result-int.patch \
	file://0538-mod-optee-clock-change-set_state-to-convert-error-st.patch \
	file://0539-mod-optee-clock-convert-TEE-results-to-framework-err.patch \
	file://0540-mod-optee-voltd_regulator-convert-TEE-results-to-fwk.patch \
	file://0541-arch-optee-fix-CFG_SCPFW_MOD_-for-product-modules.patch \
	file://0542-arch-optee-protect-scmi_process_mbx_-with-mutexes.patch \
	file://0543-prod-optee-Don-t-consider-OP-TEE-modules-when-SCP_OP.patch \
	file://0544-prod-optee-stm32mp2-psu-back-end-module-for-CPU-DVFS.patch \
	file://0545-prod-optee-stm32mp2-add-OPP-backend-for-DVFS-support.patch \
	file://0546-prod-optee-stm32mp2-add-performance-domains.patch \
	file://0547-prod-optee-stm32mp2-create-stm32-power-domain-module.patch \
	file://0548-prod-optee-stm32mp2-add-power-domains.patch \
	file://0549-prod-optee-stm32mp2-add-secondary-agent-for-cortex-m.patch \
	file://0550-drivers-remoteproc-stm32-fix-check-core-isolation.patch \
	file://0551-core-rename-STM32_M4_RPROC_ID-to-STM32MP1_M4_RPROC_I.patch \
	file://0552-drivers-stm32_remoteproc-add-support-of-the-stm32mp2.patch \
	file://0553-plat-stm32mp2-add-remoteproc-firmware-loading-suppor.patch \
	file://0554-drivers-stm32_remoteproc-add-possibility-to-set-the-.patch \
	file://0555-drivers-stm32_remoteproc-use-firewall_dt_get_alterna.patch \
	file://0556-drivers-stm32_remoteproc-support-of-the-non-secure-l.patch \
	file://0557-drivers-stm32_remoteproc-add-API-to-get-and-release-.patch \
	file://0558-drivers-stm32_remoteproc-remove-memory-protection-wa.patch \
	file://0559-drivers-remoteproc-stm32-Fix-address-size-handling-i.patch \
	file://0560-drivers-stm32_remoteproc-Add-reset-controller-suppor.patch \
	file://0561-drivers-stm32_remoteproc-Don-t-use-SRAMs-used-by-pag.patch \
	file://0562-drivers-remoteproc-rework-dma-range-management.patch \
	file://0563-drivers-remoteproc-convert-the-boot-address-to-PA-be.patch \
	file://0564-drivers-remoteproc-transform-some-debug-message-in-e.patch \
	file://0565-drivers-stm32_remoteproc-introduce-cleanup-of-firmwa.patch \
	file://0566-drivers-remoteproc-stm32mp15-remove-enable-of-MCKPRO.patch \
	file://0567-drivers-stm32_remoteproc-restore-firewall-on-low-pow.patch \
	file://0568-pta-stm32mp-remoteproc-implement-the-PTA_REMOTEPROC_.patch \
	file://0569-pta-stm32mp-remoteproc-implement-the-PTA_REMOTEPROC_.patch \
	file://0570-pta-remoteproc-Update-PTA_RPROC_LOAD_SEGMENT_SHA256-.patch \
	file://0571-pta-remoteproc-Add-support-of-the-elf-with-encryptio.patch \
	file://0572-pta-stm32mp-remoteproc-implement-read-of-encryption-.patch \
	file://0573-pta-stm32mp-remoteproc-verify-legitimacy-of-public-k.patch \
	file://0574-pta-stm32mp-remoteproc-add-support-of-ECC-public-key.patch \
	file://0575-ta-stm32mp-invoke-clean-resources-on-stop-or-on-erro.patch \
	file://0576-ta-remoteproc-Add-PTA-call-to-get-access-right-to-th.patch \
	file://0577-ta-remoteproc-Get-hash-algorithm-from-TLV.patch \
	file://0578-ta-remoteproc-Update-e32_parser_find_rsc_table-to-by.patch \
	file://0579-ta-remoteproc-add-the-platform-TLV-support.patch \
	file://0580-ta-remoteproc-Add-support-of-encrypted-firmware.patch \
	file://0581-plat-stm32mp2-add-copro-public-key-verify-flag.patch \
	file://0582-plat-stm32mp2-set-CFG_RESERVED_VASPACE_SIZE-to-32-MB.patch \
	file://0583-scripts-sign_rproc_fw-add-BOOTADDR-and-BOOTSEC-platf.patch \
	file://0584-scripts-sign_rproc_fw-Add-support-for-AES-CBC-encryp.patch \
	file://0585-scripts-sign_rproc_fw-Add-check-on-public-private-ke.patch \
	file://0586-dts-stm32-add-property-proc-id-for-IPCC-on-stm32mp23.patch \
	file://0587-dts-stm32-disable-hsem-node-in-SoC-stm32mp231.patch \
	file://0588-drivers-clk-fix-clk_set_parent_no_lock-to-properly-h.patch \
	file://0589-dts-stm32-update-mlahb-dma-range-for-the-stm32mp15-s.patch \
	file://0590-dts-stm32-add-firewall-configs-for-remoteproc-on-stm.patch \
	file://0591-dts-stm32-add-Cortex-M33-remoteproc-node-in-stm32mp2.patch \
	file://0592-dts-stm32-add-Cortex-M33-remoteproc-node-in-stm32mp2.patch \
	file://0593-dts-stm32-add-Cortex-M33-remoteproc-node-in-stm32mp2.patch \
	file://0594-dts-stm32-expose-M33-SCMI-reset-for-stm32mp25.patch \
	file://0595-dts-stm32-expose-M33-SCMI-reset-for-stm32mp23.patch \
	file://0596-dts-stm32-expose-M33-SCMI-reset-for-stm32mp21.patch \
	file://0597-dts-stm32-add-the-support-of-the-M33-remote-processo.patch \
	file://0598-dts-stm32-add-the-support-of-the-M33-remote-processo.patch \
	file://0599-dts-stm32-add-support-of-m33_rproc-for-stm32mp215f-d.patch \
	file://0600-dts-stm32-Set-display-pixel-clock-to-10-Mhz.patch \
	file://0601-dts-stm32-set-the-GPIOs-used-for-wake-up-as-secure-o.patch \
	file://0602-dts-stm32-remove-compatible-from-rcc-node-in-stm32mp.patch \
	file://0603-dts-stm32-enable-stm32-rcc-driver-for-stm32mp135f-dk.patch \
	file://0604-dts-stm32mp15-disable-non-secure-IWDG2-on-ST-boards.patch \
	file://0605-dts-stm32-stm32mp15-explicit-GPIOs-in-non-secure-sta.patch \
	file://0606-dts-stm32-remove-activation-of-RTC-nodes-for-stm32mp.patch \
	file://0607-dts-stm32-set-OSPI-clock-at-266-MHz-when-needed.patch \
	file://0608-dts-stm32-add-RIF-configuration-for-ommanager-in-stm.patch \
	file://0609-dts-stm32-align-RIF-configuration-for-MP25-EV-and-MP.patch \
	file://0610-core-add-notification-of-non-secure-virtual-interrup.patch \
	file://0611-core-allow-sending-an-async-notif-from-notifier-atom.patch \
	file://0612-core-arm-pageable-PM-sequences-extend-to-PSCI_CPU_SU.patch \
	file://0613-core-arm-psci-declare-return-values-of-PSCI_FEATURE-.patch \
	file://0614-core-lib-zlib-add-CRC32.patch \
	file://0615-drivers-stm32_irq_notif-add-new-driver.patch \
	file://0616-plat-stm32mp1-enable-CFG_STM32_IRQ_NOTIF.patch \
	file://0617-plat-stm32mp2-enable-CFG_STM32_IRQ_NOTIF-by-default.patch \
	file://0618-plat-stm32mp1-rename-PMIC1-plat-file.patch \
	file://0619-plat-stm32mp1-stm32mp1_stpmic1-add-LPLV_STOP2-mode.patch \
	file://0620-plat-stm32mp1-stm32mp1_stpmic1-handle-stpmic1-IRQs.patch \
	file://0621-plat-stm32mp1-stm32mp1_stpmic1-handle-secure-state-v.patch \
	file://0622-plat-stm32mp1-stm32mp1_stpmic1-remove-i2c-power-mana.patch \
	file://0623-plat-stm32mp1-stm32mp1_stpmic1-handle-st-mask-reset.patch \
	file://0624-plat-stm32mp1-stm32mp1_stpmic1-add-property-st-regul.patch \
	file://0625-plat-stm32mp1-stm32mp1_stpmic1-add-regulator-configu.patch \
	file://0626-plat-stm32mp1-stm32mp1_stpmic1-drop-usage-of-old-fir.patch \
	file://0627-plat-stm32mp1-rework-PMIC-usages.patch \
	file://0628-plat-stm32mp1-stm32mp1_stpmic1-remove-unused-include.patch \
	file://0629-plat-stm32mp1-allow-STM32MP1-to-use-STPMIC2.patch \
	file://0630-drivers-stpmic2-fix-disable-regulator-during-suspend.patch \
	file://0631-plat-stm32mp1-stpmic2-apply-LP-STOP-configuration-by.patch \
	file://0632-plat-stm32mp1-stpmic1-apply-LP-configuration-in-susp.patch \
	file://0633-plat-stm32mp1-stpmic1-alloc-the-LP-configuration-onl.patch \
	file://0634-drivers-stpmic1-remove-unused-functions.patch \
	file://0635-drivers-stpmic1-cache-content-of-control-and-pwrctrl.patch \
	file://0636-plat-stm32mp1-stpmic1-avoid-alternate-configuration-.patch \
	file://0637-dt-bindings-mfd-add-STPMIC1-Power-Management-IC-bind.patch \
	file://0638-dt-bindings-regulator-add-STM32MP1-Power-voltage-reg.patch \
	file://0639-dt-bindings-regulator-add-STM32MP25-POWER-bindings.patch \
	file://0640-plat-stm32mp1-stm32mp1_pwr-battery-charge.patch \
	file://0641-drivers-include-add-power-define-in-stm32mp_dt_bindi.patch \
	file://0642-plat-stm32mp1-psci-use-the-stm32_system_reset.patch \
	file://0643-plat-stm32mp1-add-low-power-drivers-for-stm32mp1.patch \
	file://0644-plat-stm32mp1-SiP-SMC-services-for-low-power.patch \
	file://0645-plat-stm32mp1-update-PSCI-ops-to-define-the-PSCI-sus.patch \
	file://0646-plat-stm32mp1-conf-enable-power-management-on-stm32m.patch \
	file://0647-plat-stm32mp1-add-function-do_reset.patch \
	file://0648-plat-stm32mp2-add-function-do_reset.patch \
	file://0649-plat-stm32mp1-add-stm32mp1_pwr_irq-driver.patch \
	file://0650-plat-stm32mp2-add-stm32mp25_pwr_irq-driver.patch \
	file://0651-plat-stm32mp2-conf-enable-PWR-interrupts.patch \
	file://0652-plat-stm32mp1-conf-enable-PWR-interrupts.patch \
	file://0653-plat-stm32mp1-add-a-function-to-enable-monitoring-in.patch \
	file://0654-plat-stm32mp2-add-a-function-to-enable-monitoring-in.patch \
	file://0655-plat-stm32mp1-stm32mp1_pwr-add-dsb-in-pwr-driver.patch \
	file://0656-plat-stm32mp1-discard-deprecated-CFG_STM32MP1_SCMI_S.patch \
	file://0657-stm32mp25-send-a-pulse-on-NRSTC1MS-pin-for-DBG_STAND.patch \
	file://0658-plat-stm32mp1-stm32mp1_pwr-fix-compatible.patch \
	file://0659-stm32mp1-use-generic-PM_HINT-and-associated-macro.patch \
	file://0660-plat-stm32mp1-STM32MP15-without-secure-service-can-s.patch \
	file://0661-plat-stm32mp2-add-stm32mp21-support-in-power-drivers.patch \
	file://0662-plat-stm32mp1-pageable-PM-sequences.patch \
	file://0663-plat-stm32mp1-pm-correct-header-file-inclusion-order.patch \
	file://0664-drivers-firewall-stm32_etzpc-remove-header-file.patch \
	file://0665-plat-stm32mp1-remove-unused-function-dump_context.patch \
	file://0666-plat-stm32mp1-remove-unused-function-pm_cb_is_valid.patch \
	file://0667-plat-stm32mp1-remove-unused-function-stm32mp_pm_retr.patch \
	file://0668-plat-stm32mp1-simplify-print_ccm_decryption_duration.patch \
	file://0669-plat-stm32mp1-clean-definition-of-teeram_bkp_mm.patch \
	file://0670-plat-stm32mp1-simplify-CFG_STM32MP1_PM_CONTEXT_VERSI.patch \
	file://0671-plat-stm32mp1-add-support-of-CRC-support-in-pm-stand.patch \
	file://0672-plat-stm32mp1-select-CFG_STM32MP1_PM_CONTEXT_VERSION.patch \
	file://0673-plat-stm32mp1-stm32mp1_pwr-retrieve-power-domain-sta.patch \
	file://0674-plat-stm32mp1-let-PWR-IRQ-to-propagate-to-parent-GIC.patch \
	file://0675-plat-stm32mp2-let-PWR-IRQ-to-propagate-to-parent-GIC.patch \
	file://0676-plat-stm32mp1-add-DDRMCE-config-in-context-V3.patch \
	file://0677-plat-stm32mp1-cleanup-the-include-of-stpmic1-file.patch \
	file://0678-plat-stm32mp1-stm32mp1_pwr-fix-access-to-EXTI-in-low.patch \
	file://0679-plat-stm32mp1-drop-unused-include-stm32mp_pm.h.patch \
	file://0680-plat-stm32mp1-drop-prototype-of-stm32_cores_reset.patch \
	file://0681-plat-stm32mp1-add-message-when-error-occur-in-psci_s.patch \
	file://0682-plat-stm32mp1-fix-return-value-of-low-power-function.patch \
	file://0683-plat-stm32mp1-psci-implement-cpu-suspend-command.patch \
	file://0684-plat-stm32mp1-pageable-PM-sequences-extend-to-PSCI_C.patch \
	file://0685-plat-stm32mp1-psci-remove-condition-on-secondary-CPU.patch \
	file://0686-plat-stm32mp1-psci-reformat-cpu_suspend-functions.patch \
	file://0687-plat-stm32mp1-pm-report-error-code-from-stm32_pwr_do.patch \
	file://0688-plat-stm32mp1-psci-transform-soc_mode-to-a-bit-field.patch \
	file://0689-plat-stm32mp1-psci-add-support-of-CPU_SUSPEND-comman.patch \
	file://0690-plat-stm32mp1-conf-disable-CFG_STM32_-_SIP-when-usin.patch \
	file://0691-stm32mp2-clear-RCC-flags-MPUP0RSTF-MPUP1RSTF.patch \
	file://0692-plat-stm32mp1-pm-context-add-an-IRQ-check-before-the.patch \
	file://0693-plat-stm32mp1-stm32mp1_pwr-check-supported-mode-for-.patch \
	file://0694-plat-stm32mp1-call-do_reset-for-PSCI-system-reset.patch \
	file://0695-drivers-stm32_rng-export-init-and-read-functions.patch \
	file://0696-plat-stm32mp1-DDR-driver-for-low-power-sequence.patch \
	file://0697-plat-stm32mp1-BKPRAM-driver-support.patch \
	file://0698-plat-stm32mp1-implement-stm32mp_stgen_base.patch \
	file://0699-plat-stm32mp1-add-global-defines-in-platform_config..patch \
	file://0700-plat-stm32mp1-update-boot_api-to-include-new-magic-n.patch \
	file://0701-plat-stm32mp1-add-stm32_exti_base-function.patch \
	file://0702-plat-stm32mp1-conf-enable-async-notif-on-STM32MP15.patch \
	file://0703-plat-stm32mp1-tzc400-reconfigure-only-when-context-h.patch \
	file://0704-dts-stm32-interrupt-notification.patch \
	file://0705-dts-stm32-add-pwr-irq-and-wakeup-pin-support-on-stm3.patch \
	file://0706-dts-stm32-remove-always-on-from-vdda18adc-in-stm32mp.patch \
	file://0707-dts-stm32mp25-add-wakeup-button-on-stm32mp25-boards.patch \
	file://0708-dts-stm32-add-support-of-wakeup-pin-on-stm32mp21-and.patch \
	file://0709-dts-stm32-add-support-of-wakeup-pin-on-stm32mp23-and.patch \
	file://0710-dts-stm32-remove-always-on-from-vdda18adc-in-stm32mp.patch \
	file://0711-dts-stm32mp15-remove-PMIC-IRQ-source-description-on-.patch \
	file://0712-dts-stm32-define-PWR-IRQ-resources-on-stm32mp15.patch \
	file://0713-dts-stm32-Add-low-power-modes-description-for-stm32m.patch \
	file://0714-dts-stm32mp15-add-low-power-modes-and-regulator-leve.patch \
	file://0715-dts-stm32mp15xx-dkx-allow-and-describe-LPLV-Stop-low.patch \
	file://0716-core-plat-stm32mp1-properly-encapsulate-pager-code-w.patch \
	file://0717-plat-stm32mp1-map-DDR-bottom-page-for-STM32MP13-as-w.patch \
	file://0718-plat-stm32mp1-move-console_init-to-init-section.patch \
	file://0719-plat-stm32mp1-ddr-disable-DDR-clock-pins-output-driv.patch \
	file://0720-plat-stm32mp1-ddr-improve-DLL-clock-management-in-se.patch \
	file://0721-dts-stm32-fix-wake-up-from-Standby-for-stm32mp13-boa.patch \
	file://0722-dts-stm32-fix-wake-up-from-Standby-for-stm32mp15-boa.patch \
	file://0723-dts-stm32-fix-wake-up-from-Standby-for-stm32mp15-dhc.patch \
	file://0724-drivers-stm32mp_provisioning-do-not-call-stm32_bsec_.patch \
	file://0725-drivers-stm32_etzpc-don-t-reconfigure-ETZPC-if-pm-hi.patch \
	file://0726-mod-wide-fix-scmi-clock-duty-cycle-support.patch \
	file://0727-dts-stm32-fix-pwr-irq-node-in-STM32MP13.patch \
	file://0728-dts-stm32-fix-pwr-irq-node-in-STM32MP15.patch \
	file://0729-mod-scmi-downgrade-NOT_FOUND-probe-logs-to-debug.patch \
	file://0730-core-add-panic-for-abort-type-FAULT_TYPE_EXTERNAL_AB.patch \
	file://0731-plat-stm32mp2-disable-stm32_debug_suspend-when-debug.patch \
	file://0732-plat-stm32mp1-conf-disable-DYN_CONFIG.patch \
	file://0733-core-kernel-use-spinlock-instead-of-trylock-in-mutex.patch \
	file://0734-ta-pkcs11-check-output-buffer-size-on-get-attribute-.patch \
	file://0735-ta-pkcs11-check-template-consistency-on-get-attribut.patch \
	file://0736-ta-pkcs11-fix-attribute-output-size-if-too-small-on-.patch \
	file://0737-core-crypto_api-fix-underflow-in-emsa_pkcs1_v1_5_enc.patch \
	file://0738-core-aes-gcm-fix-512-MiB-overflow-and-enforce-NIST-l.patch \
	file://0739-core-fix-cleanup_shm_refs-attribute-masking.patch \
	file://0740-libutils-fix-nesting-of-MIN-and-MAX-macros.patch \
	file://0741-ta-pkcs11-bound-attribute-reads-in-__trace_attribute.patch \
	file://0742-ta-pkcs-11-limit-indirect-attribute-recursion-depth.patch \
	file://0743-core-copy-subkey_version-in-shdr_load_pub_key.patch \
	file://0744-Squashed-commit-upgrading-to-mbedtls-3.6.6.patch \
	file://0745-plat-stm32mp1-fix-low-power-drivers-for-stm32mp1.patch \
	file://0746-plat-stm32mp1-remove-stm32mp1_pm_domain.patch \
	file://0747-plat-stm32mp1-stpmic2-remove-STM32_PM_DEFAULT-in-bin.patch \
	file://0748-plat-stm32mp-add-STM32_PM_SWITCH_OFF-define.patch \
	file://0749-dt-bindings-mfd-add-system-power-controller-properti.patch \
	file://0750-plat-stm32mp1-stpmic1-support-system-power-controlle.patch \
	file://0751-drivers-stpmic2-support-system-power-controller.patch \
	file://0752-dts-stm32-add-system-power-controller-for-stpmic1-in.patch \
	file://0753-plat-stm32mp1-fix-shutdown-support.patch \
	file://0754-dts-stm32-remove-system_off_soc-in-pwr-node-of-stm32.patch \
	file://0755-plat-stm32mp1-remove-system_off_soc-and-STM32_PM_SHU.patch \
	file://0756-dt-bindings-regulator-remove-system_off_soc_mode-in-.patch \
	file://0757-dt-bindings-clock-OP-TEE-specific-STM32MP2-clock-and.patch \
	file://0758-dts-stm32-expose-vdd33ucpd-regulator-to-cortex-A35-a.patch \
	file://0759-dts-stm32-expose-vdd33ucpd-regulator-to-cortex-A35-a.patch \
	file://0760-drivers-crypto-stm32_cryp-wait-for-busy-bit-before-s.patch \
	file://0761-dts-stm32-fix-warning-in-stm32mp15-boards.patch \
	file://0762-mk-compile.mk-only-check-unique_unit_address-on-enab.patch \
	file://0763-core-pta-stm32mp-remoteproc-parse-RSA-2048-DER-key.patch \
	file://0764-core-pta-stm32mp-remoteproc-support-RSA-4096-DER-key.patch \
	file://0765-core-pta-stm32mp-remoteproc-rework-parse-of-ECC-DER-.patch \
	file://0766-dts-stm32-remove-always-on-from-vdda18adc-in-stm32mp.patch \
	file://0767-dts-stm32-set-ck_ker_lvdsphy-to-13.5Mhz-on-stm32mp2-.patch \
	file://0768-drivers-counter-stm32_stgen-keep-STGEN-enabled-while.patch \
	file://0769-dts-stm32-forward-WoL-IRQ-with-an-asynchronous-notif.patch \
	file://0770-core-arm-boot-add-function-plat_system_reset.patch \
	file://0771-core-panic-add-possibility-to-reset-the-platform-aft.patch \
	file://0772-drivers-stm32_tamp-replace-do_reset-by-plat_system_r.patch \
	file://0773-core-arm-psci-call-plat_system_reset-as-a-default-im.patch \
	file://0774-plat-stm32mp1-psci-use-the-default-implementation-of.patch \
	file://0775-plat-stm32mp-implement-plat_system_reset-for-stm32mp.patch \
	file://0776-dts-stm32-add-the-sleep-configuration-for-i2c4-pins.patch \
	file://0777-dts-stm32-Use-a-generic-name-for-the-PMIC-node.patch \
	file://0778-drivers-stm32_risaf-fix-warning-when-building-for-aa.patch \
	file://0779-Add-missing-st-regulator-sink-source-for-DDR-regulat.patch \
	file://0780-drivers-scmi-msg-enable-extended-support-for-duty-cy.patch \
	file://0781-clk-stm32-remove-support-of-OPP-except-for-MPU.patch \
	file://0782-plat-stm32mp1-default-enable-hardware-RNG-for-STM32M.patch \
	file://0783-dt-bindings-regulator-add-OP-TEE-non-secure-compatib.patch \
	file://0784-core-REE-FS-fix-counter-misaligment-when-calling-ree.patch \
	file://0785-core-REE-FS-do-not-close-dirh-file-when-ree_fs_readd.patch \
	file://0786-drivers-stm32_rif-fix-32-bit-RIF-bit-overflow.patch \
	file://0787-core-add-stm32_ltdc-driver.patch \
	file://0788-drivers-stm32_ltdc-fix-uninitialized-variable.patch \
	file://0789-drivers-stm32_ltdc-remove-stm32_pinctrl_set_secure_c.patch \
	file://0790-drivers-stm32_ltdc-apply-secure-pinctrl.patch \
	file://0791-drivers-stm32_ltdc-sync-comment-with-code.patch \
	file://0792-drivers-stm32_ltdc-fix-shadow-registers-usage.patch \
	file://0793-drivers-stm32-ltdc-set-configuration-register-masks-.patch \
	file://0794-drivers-add-frame_buffer-driver-support.patch \
	file://0795-libutee-add-Trusted-UI-code.patch \
	file://0796-core-add-pseudo-TA-for-TUI.patch \
	file://0797-libutee-add-TUI-interface-and-implementation.patch \
	file://0798-libpng-import-library-version-to-1.6.37.patch \
	file://0799-zlib-move-zlib-from-core-to-lib-to-share-with-TAs.patch \
	file://0800-scripts-render_font.py-for-Python-3.x.patch \
	file://0801-scripts-render_font.py-use-PIL.patch \
	file://0802-scripts-fix-code-style-issues-in-render_font.py.patch \
	file://0803-libpng-fix-build-issue-when-NEON-is-disabled.patch \
	file://0804-plat-stm32mp1-display-add-wrapper.patch \
	file://0805-plat-stm32mp2-display-add-wrapper.patch \
	file://0806-plat-stm32mp2-conf-enable-the-trusted-UI-support-for.patch \
	file://0807-dts-stm32-add-ltdc-pins-settings-for-stm32mp135f-dk.patch \
	file://0808-dts-stm32mp13-add-display-support-for-stm32mp135f-dk.patch \
	file://0809-dts-stm32-add-ltdc-support-on-stm32mp2.patch \
	file://0810-drivers-stm32-tui-update-pixel-format.patch \
	file://0811-drivers-stm32-tui-set-alpha-to-framebuffer.patch \
	file://0812-dts-stm32-add-ltdc-support-on-stm32mp21.patch \
	file://0813-dts-stm32-add-ltdc-pins-settings-for-stm32mp215f-dk.patch \
	file://0814-dts-stm32-add-ltdc-support-on-stm32mp23.patch \
	file://0815-plat-stm32mp1-conf-enable-the-trusted-UI-support-for.patch \
	file://0816-plat-stm32mp1-conf-default-enable-CFG_STM32_LTDC.patch \
	file://0817-dts-stm32-LTDC-secure-non-secure-pinctrl-for-stm32mp.patch \
	file://0818-dts-stm32-secure-LTDC-on-stm32mp135f-dk.patch \
	file://0819-dt-bindings-regulator-add-support-of-vrefbuf-on-STM3.patch \
	file://0820-dt-bindings-hwlock-add-st-protreg-properties-for-stm.patch \
	file://0821-dt-bindings-rtc-add-st-protreg-properties-for-stm32m.patch \
	file://0822-dt-bindings-pinctrl-add-st-protreg-properties-for-st.patch \
	file://0823-dt-bindings-mailbox-add-st-protreg-properties-for-st.patch \
	file://0824-dt-bindings-memory-controller-add-st-protreg-propert.patch \
	file://0825-dt-bindings-memory-controller-add-st-protreg-propert.patch \
	file://0826-plat-stm32mp2-conf-default-enable-CFG_RESET_SYSTEM_O.patch \
	file://0827-plat-stm32mp1-conf-default-enable-CFG_RESET_SYSTEM_O.patch \
	file://0828-dt-bindings-regulator-add-OP-TEE-properties-for-stm3.patch \
	file://0829-drivers-stm32_rng-fix-clock-support-for-STM32MP2xx-p.patch \
	file://0830-module-scmi_system_power-allow-module-to-work-withou.patch \
	file://0831-module-scmi_reset_domain-make-reset-notification-con.patch \
	file://0832-module-scmi_system_power-fix-graceful-in-system-powe.patch \
	file://0833-module-scmi-power_domain-change-domain-count-check.patch \
	file://0834-module-power_domain-fix-for-async-notification.patch \
	file://0835-arch-add-tfm-architecture.patch \
	file://0836-product-add-tfm-stm32mp2-product.patch \
	file://0837-plat-stm32mp2-conf-disable-CFG_RESET_SYSTEM_ON_PANIC.patch \
	file://0838-stm32mp1-remove-PLL1-settings-from-context.patch \
	file://0839-plat-stm32mp1-conf-default-disable-CFG_STM32_-_SIP-c.patch \
	file://0840-dts-stm32-set-i2c4-as-secure-and-control-PMIC-on-stm.patch \
	file://0841-dts-stm32-set-i2c4-as-secure-and-control-PMIC-on-stm.patch \
	file://0842-dts-stm32-change-LPTIM4-source-clock-on-stm32mp135f-.patch \
	file://0843-core-kernel-from_-to_bounce_params-relates-to-CFG_WI.patch \
	file://0844-plat-stm32mp1-remove-empty-flavor-from-platform-bann.patch \
	file://0845-plat-stm32mp2-remove-empty-flavor-from-platform-bann.patch \
	file://0846-drivers-stm32_risab-save-restore-context-regardless-.patch \
	file://0847-ta-pkcs11-release-private-resources-on-logout.patch \
	file://0848-ta-pkcs11-fix-stack-buffer-overflow-in-unwrap_rsa_ae.patch \
	file://0849-plat-stm32mp1-add-trace-in-stm32mp1_get_lp_soc_mode.patch \
	file://0850-plat-stm32mp2-sysconf-fix-CA35SS-base-address-name.patch \
	file://0851-core-pta-return-when-we-fail-to-register-receive-cha.patch \
	file://0852-dts-stm32-select-the-LSI-clock-for-the-flexclkgen-re.patch \
	file://0853-drivers-stm32_uart-fix-baud-rate-computation.patch \
	file://0854-module-dvfs-check-get_domain_ctx-for-NULL-before-use.patch \
	file://0855-module-power_domain-fix-element_table-resource-leak.patch \
	file://0856-module-scmi_perf-fix-size_t-underflow-in-find_opp_fo.patch \
	file://0857-module-optee_clock-check-elt_id_to_ctx-for-NULL-in-e.patch \
	file://0858-module-stm32_opp-check-elt_id_to_ctx-for-NULL-in-ele.patch \
	file://0859-module-power_domain-fix-dead-check-and-NULL-parent-d.patch \
	file://0860-prod-optee-stm32mp2-check-the-rollback-results-in-st.patch \
	file://0861-prod-optee-clock-fix-get_range-for-32-bit-build.patch \
	file://0862-product-tfm-stm32mp2-update-trace-in-tfm-modules.patch \
	file://0863-clk-stm32mp25-always-enable-RTC-autonomous-mode-cloc.patch \
	file://0864-libutee-tui_keyboard-fix-uninitialized-res-in-keyboa.patch \
	file://0865-lib-libpng-fix-uninitialized-tRNS-buffer-harden-zTXt.patch \
	file://0866-lib-libpng-validate-PNG-write-buffers-and-pass-index.patch \
	file://0867-clk-stm32-fix-priv-resource-leak-in-hse-monitoring-p.patch \
	file://0868-clk-stm32-fix-unchecked-array-index-bound-checks.patch \
	file://0869-clk-stm32-check-stm32mp_rcc_clock_id_to_clk-for-NULL.patch \
	file://0870-core-boot-replace-assert-only-NULL-checks-with-real-.patch \
	file://0871-core-firewall-acknowledge-snprintf-return-value.patch \
	file://0872-drivers-stm32_exti-fix-out-of-bounds-access-to-hiera.patch \
	file://0873-drivers-stm32_lptimer-fix-NULL-deref-and-use-after-f.patch \
	file://0874-drivers-regulator-fix-NULL-deref-and-unchecked-snpri.patch \
	file://0875-drivers-stm32_cpu_opp-check-bypass-parent-clock-befo.patch \
	file://0876-plat-stm32mp1-scmi-replace-assert-only-realloc-check.patch \
	file://0877-plat-stm32mp2-check-dbgmcu_clk-for-NULL-in-stm32_deb.patch \
	file://0878-core-pta-stm32mp-remoteproc-use-a-bitwise-and-for-th.patch \
	file://0879-pta-scmi-remove-a-duplicated-parameter-check.patch \
	file://0880-ta-remoteproc-check-remoteproc_clean_resources-retur.patch \
	file://0881-ta-pkcs11-check-delete-result-and-drop-unused-assign.patch \
	file://0882-clk-stm32-keep-the-parent-id-error-code-signed.patch \
	file://0883-clk-stm32-reject-a-null-input-frequency-for-the-PLL1.patch \
	file://0884-drivers-stm32_rifsc-check-pointers-before-dereferenc.patch \
	file://0885-drivers-stm32_cpu_opp-fix-res-type-and-unreachable-r.patch \
	file://0886-drivers-stm32_rtc-fix-alarm-seconds-mask-test.patch \
	file://0887-drivers-regulator-compute-the-level-range-without-un.patch \
	file://0888-drivers-stm32_remoteproc-use-TEE_Result-for-the-stat.patch \
	file://0889-drivers-stm32_exti-check-the-TDCID-state-read-result.patch \
	file://0890-drivers-stm32-ltdc-check-the-firewall-restore-result.patch \
	file://0891-drivers-stpmic2-bound-the-regulator-id-instead-of-a-.patch \
	file://0892-drivers-stm32_etzpc-remove-a-dead-switch-default.patch \
	file://0893-drivers-stm32_tamp-remove-a-dead-switch-default.patch \
	file://0894-drivers-stm32_cpu_opp-fix-off-by-one-in-stm32_cpu_op.patch \
	file://0895-drivers-stm32_cpu_opp-restore-previous-OPP-on-set_op.patch \
	file://0896-ta-pkcs11-invalidate-handles-before-freeing-token-ob.patch \
	file://0897-libutee-tui-force-image-alpha-color-to-0xFF.patch \
	file://0898-scmi-msg_smt-clamp-max_payload_size-to-the-runtime-o.patch \
	file://0899-mod-scmi_clock-fix-get-config-to-match-specification.patch \
	file://0900-stm32mp1-add-stm32mp_pm_init_mailbox.patch \
	file://0901-drivers-stm32_uart-fix-baudrate-parsing-and-prescale.patch \
	file://0902-core-pta-secstor_ta-check-against-REE-FS-TA-downgrad.patch \
	file://0903-core-fs_htree-fix-incorrect-data-type-in-create_and_.patch \
	file://0904-core-fs_htree-prevent-possible-hash-tree-reset.patch \
	file://0905-ta-pkcs11-separate-data-and-key-encryption-keys.patch \
	file://0906-ta-pkcs11-enforce-separation-of-data-and-key-encrypt.patch \
	file://0907-core-ltc-check-public-key-before-DH-derivation.patch \
	file://0908-drivers-stm32_remoteproc-fix-rproc-resource-leak-in-.patch \
	file://0909-core-pta-attestation-use-temp-out-buffer.patch \
	file://0910-prod-optee-stm32mp2-add-define-to-use-variable-only-.patch \
	file://0911-clk-stm32-fix-panic-after-calibration-failure.patch \
	file://0912-clk-stm32-deactivate-HSI-monitor-interrupt-during-lo.patch \
	file://0913-dts-stm32-stm32mp2-add-support-for-STM32MP23xx-STM32.patch \
	"
