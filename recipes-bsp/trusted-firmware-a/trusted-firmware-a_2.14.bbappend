FILESEXTRAPATHS:prepend:dh-stm32mp13-dhsom := "${THISDIR}/files/dh-stm32mp13-dhsom:"
FILESEXTRAPATHS:prepend:dh-stm32mp2-dhsom := "${THISDIR}/files/dh-stm32mp2-dhsom:"

COMPATIBLE_MACHINE:dh-stm32mp13-dhcor-dhsbc = "dh-stm32mp13-dhcor-dhsbc"
COMPATIBLE_MACHINE:dh-stm32mp23-dhsom = "dh-stm32mp23-dhsom"
COMPATIBLE_MACHINE:dh-stm32mp25-dhsom = "dh-stm32mp25-dhsom"

TFA_PLATFORM:dh-stm32mp13-dhcor-dhsbc = "stm32mp1"
TFA_PLATFORM:dh-stm32mp2-dhsom = "stm32mp2"

TFA_BUILD_TARGET:dh-stm32mp13-dhcor-dhsbc = "all fip"
TFA_INSTALL_TARGET:dh-stm32mp13-dhcor-dhsbc = "tf-a-stm32mp135f-dhcor-dhsbc.stm32 fip.bin"

TFA_BUILD_TARGET:dh-stm32mp2-dhsom = "all fip"
TFA_INSTALL_TARGET:dh-stm32mp23-dhsom = "tf-a-stm32mp23xx-dhcos-som.stm32 fip.bin"
TFA_INSTALL_TARGET:dh-stm32mp25-dhsom = "tf-a-stm32mp25xx-dhcos-som.stm32 fip.bin"

TFA_BUILD_TARGET:append:dh-stm32mp23-dhcos-bb = " fip-ddr"
TFA_INSTALL_TARGET:append:dh-stm32mp23-dhcos-bb = " fip-ddr.bin"

TFA_BUILD_TARGET:append:dh-stm32mp25-dhcos-bb = " fip-ddr"
TFA_BUILD_TARGET:append:dh-stm32mp25-dhcos-dhsbc = " fip-ddr"
TFA_INSTALL_TARGET:append:dh-stm32mp25-dhcos-bb = " fip-ddr.bin"
TFA_INSTALL_TARGET:append:dh-stm32mp25-dhcos-dhsbc = " fip-ddr.bin"

do_compile[depends] += "${@'optee-os:do_deploy u-boot-mainline:do_deploy' if 'dh-stm32mp13-dhcor-dhsbc' in d.getVar('MACHINEOVERRIDES', True).split(':') else ' '}"

do_compile[depends] += "${@'optee-os:do_deploy u-boot-mainline:do_deploy' if 'dh-stm32mp2-dhsom' in d.getVar('MACHINEOVERRIDES', True).split(':') else ' '}"

EXTRA_OEMAKE:append:dh-stm32mp13-dhcor-dhsbc = " \
	AARCH32_SP=optee \
	ARCH=aarch32 \
	ARM_ARCH_MAJOR=7 \
	BL32=${DEPLOY_DIR_IMAGE}/optee/tee-header_v2.bin \
	BL32_EXTRA1=${DEPLOY_DIR_IMAGE}/optee/tee-pager_v2.bin \
	BL32_EXTRA2=${DEPLOY_DIR_IMAGE}/optee/tee-pageable_v2.bin \
	BL33=${DEPLOY_DIR_IMAGE}/u-boot-nodtb.bin \
	BL33_CFG=${DEPLOY_DIR_IMAGE}/u-boot.dtb \
	DTB_FILE_NAME=stm32mp135f-dhcor-dhsbc.dtb \
	STM32MP_EMMC=1 \
	STM32MP_RCC_NS=1 \
	STM32MP_SPI_NOR=1 \
	STM32MP_USB_PROGRAMMER=1 \
	VERSION=${PV} \
	"

EXTRA_OEMAKE:append:dh-stm32mp2-dhsom = " \
	BL32=${DEPLOY_DIR_IMAGE}/optee/tee-header_v2.bin \
	BL32_EXTRA1=${DEPLOY_DIR_IMAGE}/optee/tee-pager_v2.bin \
	BL33=${DEPLOY_DIR_IMAGE}/u-boot-nodtb.bin \
	BL33_CFG=${DEPLOY_DIR_IMAGE}/u-boot.dtb \
	SPD=opteed \
	STM32MP_DDR_FW=drivers/st/ddr/phy/firmware/bin/stm32mp2/lpddr4_pmu_train.bin \
	STM32MP_LPDDR4_TYPE=1 \
	STM32MP_EMMC=1 \
	STM32MP_EMMC_BOOT=1 \
	STM32MP_SDMMC=1 \
	STM32MP_SPI_NOR=1 \
	VERSION=${PV} \
	"

EXTRA_OEMAKE:append:dh-stm32mp23-dhsom = " DTB_FILE_NAME=stm32mp23xx-dhcos-som.dtb"
EXTRA_OEMAKE:append:dh-stm32mp25-dhsom = " DTB_FILE_NAME=stm32mp25xx-dhcos-som.dtb"

EXTRA_OEMAKE:append:dh-stm32mp23-dhcos-bb = " STM32MP_USB_PROGRAMMER=1"
EXTRA_OEMAKE:append:dh-stm32mp25-dhcos-bb = " STM32MP_USB_PROGRAMMER=1"
EXTRA_OEMAKE:append:dh-stm32mp25-dhcos-dhsbc = " STM32MP_USB_PROGRAMMER=1"

# These convenience settings must not be applied in production builds.
EXTRA_OEMAKE:append:dh-stm32mp23-dhcos-bb = " STM32MP_SUPPORT_PM=1"
EXTRA_OEMAKE:append:dh-stm32mp25-dhcos-bb = " STM32MP_SUPPORT_PM=1"
EXTRA_OEMAKE:append:dh-stm32mp25-dhcos-dhsbc = " STM32MP_SUPPORT_PM=1"

SRC_URI:append:dh-stm32mp13-dhcor-dhsbc = " \
	file://0001-feat-stm32mp1-add-optional-clearing-of-RCC_SECCFGR.patch \
	file://0002-feat-stm32mp1-fdts-add-support-for-STM32MP13xx-DHCOR.patch \
	"

# Workaround for ST downstream 0145-feat-st-ddr-add-STM32MP2-PHY-driver.patch
# which includes binary blobs in the patch file. OE default patchtool, quilt,
# rejects such bad patches. Work around this by using git to apply the patches.
PATCHTOOL:dh-stm32mp2-dhsom = "git"

SRC_URI:append:dh-stm32mp2-dhsom = " \
	file://0001-fix-st-use-KEEP-for-.dtb_image-and-.bl2_image-sectio.patch \
	file://0002-refactor-st-simplify-rule-to-build-.stm32-file.patch \
	file://0003-feat-st-allow-the-use-of-clang-as-linker.patch \
	file://0004-feat-st-disable-FWU-on-serial-boot-devices.patch \
	file://0005-feat-st-add-STM32MP_SUPPORT_PM-flag.patch \
	file://0006-feat-stm32mp2-stub-PM-code-in-serial-boot.patch \
	file://0007-feat-stm32mp2-add-a-ca35ss-driver.patch \
	file://0008-feat-st-add-stm32mp_gic_cpuif_enable-disable.patch \
	file://0009-feat-stm32mp2-manage-core-1-enabling.patch \
	file://0010-fix-st-restore-support-for-multiple-entries-in-DTB_F.patch \
	file://0011-fix-mmc-align-sd_switch_func_status-struct.patch \
	file://0012-feat-stm32mp13-manage-potential-tamper-while-boot.patch \
	file://0013-refactor-stm32mp1-create-reset_backup_domain-functio.patch \
	file://0014-feat-stm32mp15-fdts-add-STM32M157F-boards.patch \
	file://0015-refactor-stm32mp15-fdts-remove-unused-fw-config-file.patch \
	file://0016-feat-stm32mp1-update-STPMIC1-driver-to-handle-more-p.patch \
	file://0017-feat-stm32mp1-fdts-add-DDR-power-supplies-descriptio.patch \
	file://0018-feat-stm32mp1-rework-ddr-supplies-handling.patch \
	file://0019-fix-st-ddr-improve-error-management-during-PHY-init-.patch \
	file://0020-fix-st-ddr-manage-CID-filtering-when-accessing-PWR_C.patch \
	file://0021-fix-st-ddr-manage-semaphore-with-CID-filtering.patch \
	file://0022-fix-st-ddr-change-retention-disable-management.patch \
	file://0023-feat-stm32mp15-fdts-apply-RCC-security.patch \
	file://0024-feat-stm32mp23-manage-STM32MP23-DT-overlays.patch \
	file://0025-feat-stm32mp23-fdts-add-fw-config-file.patch \
	file://0026-feat-stm32mp23-add-SoC-part-numbers.patch \
	file://0027-feat-stm32mp23-fdts-add-SoC-DT-files.patch \
	file://0028-feat-stm32mp23-add-RIFSC-IDs-bindings.patch \
	file://0029-feat-stm32mp23-fdts-add-STM32MP235F-DK-board.patch \
	file://0030-feat-stm32mp2-display-package-type-for-STM32MP23.patch \
	file://0031-feat-stm32image-add-header-version-2.3-support.patch \
	file://0032-feat-stm32mp21-fdts-add-SoC-DT-files.patch \
	file://0033-feat-stm32mp21-fdts-add-pinctrl-DT-file.patch \
	file://0034-feat-stm32mp21-manage-STM32MP21-DT-overlays.patch \
	file://0035-feat-stm32mp21-fdts-add-fw-config-file.patch \
	file://0036-feat-stm32mp21-update-SRAM1-and-RETRAM-base-address.patch \
	file://0037-feat-stm32mp21-remove-GPIOJ-and-GPIOK.patch \
	file://0038-feat-st-bsec3-add-STM32MP21-version-support.patch \
	file://0039-feat-st-bsec-update-OTPCR-masks-for-STM32MP21.patch \
	file://0040-feat-stm32mp21-update-STM32-header-size-for-STM32MP2.patch \
	file://0041-feat-stm32mp2-introduce-MCE-encryption-level-in-RISA.patch \
	file://0042-feat-stm32mp21-update-boot-API-header-version.patch \
	file://0043-feat-stm32mp21-add-SoC-part-numbers.patch \
	file://0044-feat-stm32mp2-define-UART8-and-UART9-under-STM32MP25.patch \
	file://0045-feat-st-rif-add-RISAF-MCE-support-for-STM32MP21.patch \
	file://0046-feat-stm32mp2-manage-RISAF-MCE-key-for-STM32MP21.patch \
	file://0047-feat-st-usb-enable-USBOTG-DFU-for-STM32MP21.patch \
	file://0048-feat-stm32mp21-enable-USBOTG-DFU.patch \
	file://0049-feat-stm32mp21-add-RIFSC-IDs-bindings.patch \
	file://0050-feat-stm32mp2-include-dedicated-RIFSC-ID-headers.patch \
	file://0051-feat-st-rif-add-STM32MP2x-support-in-RIFSC-driver.patch \
	file://0052-feat-stm32mp2-add-RIFSC-USB-configuration-for-varian.patch \
	file://0053-feat-stm32mp2-add-a-new-stm32mp21-power-compatible.patch \
	file://0054-feat-st-pmic-add-support-for-STPMIC1L-and-STPMIC2L.patch \
	file://0055-feat-stm32mp1-make-stpmic2-usable-for-STM32MP1.patch \
	file://0056-feat-st-pmic-add-default-regulator-configuration-for.patch \
	file://0057-feat-st-pmic-display-information-only-in-BL2.patch \
	file://0058-feat-st-pmic-add-a-switch-off-function.patch \
	file://0059-feat-st-pmic-force-PMIC-and-its-I2C-secure-in-BL2.patch \
	file://0060-refactor-stm32mp13-fdts-remove-secure-status-for-PMI.patch \
	file://0061-feat-fdts-introduce-STM32MP21-pinctrl-files.patch \
	file://0062-feat-stm32mp21-fdts-add-STM32MP215F-DK-board.patch \
	file://0063-feat-stm32mp2-fdts-remove-ramp-delay-on-ddr-supply.patch \
	file://0064-fix-stm32mp2-reorder-DDR3-and-DDR4-power-supply-sequ.patch \
	file://0065-feat-st-i2c-compute-dynamically-I2C-timings.patch \
	file://0066-feat-psci-update-PSCI_MAX_PWR_LVL-for-extented-State.patch \
	file://0067-feat-stm32mp2-update-topology-for-PSCI.patch \
	file://0068-feat-stm32mp1-add-Backup-SRAM-definitions.patch \
	file://0069-feat-st-protect-access-on-PWR-registers.patch \
	file://0070-feat-stm32mp1-add-low-power-context-management.patch \
	file://0071-feat-stm32mp1-update-boot_api.h-for-low-power.patch \
	file://0072-feat-st-manage-ROM-code-boot_action-field.patch \
	file://0073-feat-stm32mp1-implement-stm32mp_is_wakeup_from_stand.patch \
	file://0074-feat-st-ddr-add-DDR-self-refresh-management.patch \
	file://0075-feat-stm32mp1-check-an-address-is-inside-backup-SRAM.patch \
	file://0076-feat-dt-bindings-add-low-power-defines-for-STM32MP1.patch \
	file://0077-feat-stm32mp1-manage-low-power.patch \
	file://0078-feat-stm32mp1-save-zq0cr0-in-backup-context-at-boot-.patch \
	file://0079-feat-stm32mp1-check-the-context-is-saved.patch \
	file://0080-feat-stm32mp1-add-MCE-master-key-services-for-STM32M.patch \
	file://0081-feat-stm32mp1-save-restore-MCE-key.patch \
	file://0082-feat-stm32mp1-add-LPLV-Stop2-mode.patch \
	file://0083-fix-stm32mp1-do-not-modify-CPU-voltage-after-standby.patch \
	file://0084-feat-st-regulator-introduce-STM32-GPIO-regulator.patch \
	file://0085-feat-stm32mp1-enable-GPIO-regulator-on-STM32MP1.patch \
	file://0086-feat-stm32mp1-default-load-optee-in-DDR.patch \
	file://0087-fix-stm32mp1-flush-data-cache-at-the-end-of-BL2.patch \
	file://0088-fix-stm32mp1-check-DDR-refresh-to-restore-firewall-c.patch \
	file://0089-feat-stm32mp13-save-restore-DDRMCE-config.patch \
	file://0090-feat-st-drivers-add-stm32_mce_reload_configuration.patch \
	file://0091-feat-fwu-introduce-plat_fwu_is_enabled.patch \
	file://0092-feat-st-add-a-function-to-skip-storage-init-after-st.patch \
	file://0093-feat-st-skip-storage-init-after-standby-if-possible.patch \
	file://0094-feat-stm32mp1-manage-STM32MP15-rev.Y.patch \
	file://0095-feat-stm32mp1-fdts-use-iwdg1-instead-of-iwdg2.patch \
	file://0096-feat-st-lock-the-encryption-key-at-the-end-of-BL2.patch \
	file://0097-fix-nand-add-read-parameter-page-retry.patch \
	file://0098-feat-st-fmc-make-the-reset-optional.patch \
	file://0099-feat-st-fmc-update-the-driver-to-support-STM32MP25.patch \
	file://0100-feat-stm32mp25-fdts-add-FMC2-support.patch \
	file://0101-feat-stm32mp2-add-support-for-SPI-NAND-raw-NAND-boot.patch \
	file://0102-feat-st-add-a-helper-to-get-OSPI-memory-mapped-size.patch \
	file://0103-feat-stm32mp2-add-OSPI-support.patch \
	file://0104-feat-stm32mp25-fdts-add-OSPI-support.patch \
	file://0105-feat-mtd-add-dirmap_read-callback.patch \
	file://0106-feat-spi-nand-use-spi_mem_dirmap_read.patch \
	file://0107-feat-mtd-spi_nor-use-spi_mem_dirmap_read.patch \
	file://0108-feat-st-spi-add-dirmap_read-support.patch \
	file://0109-feat-st-spi-manage-multiple-resets.patch \
	file://0110-feat-mtd-spi_mem-add-octal-mode-support.patch \
	file://0111-feat-st-spi-add-octal-mode-support.patch \
	file://0112-feat-mtd-spi_nor-add-octal-read-commands.patch \
	file://0113-feat-st-fmc-add-RIF-support.patch \
	file://0114-feat-st-fmc-reset-FMC2-if-CFGR-access-is-allowed.patch \
	file://0115-refactor-st-spi-move-on-IOM-bindings.patch \
	file://0116-refactor-stm32mp2-fdts-move-on-IOM-bindings.patch \
	file://0117-refactor-mtd-update-NOR-bank-management.patch \
	file://0118-feat-mtd-add-4-bytes-address-opcodes-for-NOR.patch \
	file://0119-feat-stm32mp2-use-4-bytes-fast-read-opcode.patch \
	file://0120-fix-st-spi-enable-delay-block-bypass.patch \
	file://0121-fix-st-spi-enable-SSHIFT.patch \
	file://0122-fix-st-spi-always-check-SR_TCF-flags-in-stm32_omi_wa.patch \
	file://0123-fix-stm32mp2-add-quad-SPI-NOR-configuration.patch \
	file://0124-feat-fdts-add-OSPI-muxing.patch \
	file://0125-feat-fdts-add-OSPI-nodes-on-eval-board.patch \
	file://0126-feat-stm32mp2-syscfg-Add-IO-compensation-handling.patch \
	file://0127-feat-stm32mp2-add-PWR-driver-for-STM32MP2.patch \
	file://0128-feat-stm32mp2-enable-watchdog-driver.patch \
	file://0129-feat-fdts-add-watchdog-support-for-STM32MP2.patch \
	file://0130-feat-stm32mp2-add-UART-driver-for-programmer.patch \
	file://0131-feat-st-add-interface-to-get-otp-from-phandle.patch \
	file://0132-feat-st-add-a-provisioning-mode-to-manage-shadow-OTP.patch \
	file://0133-feat-fdts-add-default-hconf1-OTP-value-for-stm32mp25.patch \
	file://0134-feat-st-add-an-API-to-retrieve-STM32-image-header.patch \
	file://0135-feat-st-bsec-add-hardware-key-information-in-bsec-st.patch \
	file://0136-refactor-st-bsec-fix-bsec-state-initialisation.patch \
	file://0137-feat-stm32mp2-rename-stm32_otp_is_closed_device-to-s.patch \
	file://0138-feat-stm32mp2-check-if-chip-is-in-closed-state.patch \
	file://0139-feat-st-crypto-change-PKA-compatible-name.patch \
	file://0140-feat-stm32mp13-fdts-change-PKA-compatible-name.patch \
	file://0141-feat-stm32mp25-fdts-add-crypro-peripherals.patch \
	file://0142-fix-stm32mp25-fdts-align-rcc-node-with-Linux.patch \
	file://0143-feat-st-manage-BL31-certificates.patch \
	file://0144-feat-stm32mp2-add-DDR-firmware-OID.patch \
	file://0145-feat-stm32mp2-configure-cert_tool-for-new-images.patch \
	file://0146-feat-stm32mp1-add-PDEF_EXTS-management.patch \
	file://0147-feat-stm32mp2-fdts-enable-HASH-PKA-and-SAES-for-eval.patch \
	file://0148-feat-stm32mp2-fdts-add-security-nodes.patch \
	file://0149-feat-stm32mp2-fdts-update-DT-for-TBBR.patch \
	file://0150-feat-stm32mp2-add-support-for-trusted-boot.patch \
	file://0151-feat-stm32mp25-adapt-authentication-status.patch \
	file://0152-refactor-stm32mp2-update-authentication-check-for-ST.patch \
	file://0153-docs-stm32mp2-add-trusted-boot-commands.patch \
	file://0154-feat-build-add-encrypted-payload-as-FIP-dependency.patch \
	file://0155-feat-stm32mp2-add-BL31-BL32-encryption-support.patch \
	file://0156-feat-stm32mp2-add-trusted-boot-for-serial-boot-devic.patch \
	file://0157-feat-st-get-encryption-key-info-from-DT.patch \
	file://0158-feat-stm32mp2-save-encryption-key-info-before-overwr.patch \
	file://0159-feat-stm32mp25-fdts-add-SD-card-supplies-on-eval-boa.patch \
	file://0160-feat-stm32mp25-fdts-add-eMMC-supplies-on-eval-board.patch \
	file://0161-docs-changelog-reorder-ST-drivers-scopes.patch \
	file://0162-docs-changelog-add-st-rif-scope.patch \
	file://0163-feat-stm32mp2-save-a-copy-of-STM32-header.patch \
	file://0164-feat-st-add-support-for-external-device-tree-files.patch \
	file://0165-feat-stm32mp2-add-BKPSRAM-base-address.patch \
	file://0166-feat-stm32mp2-add-a-low-power-context.patch \
	file://0167-feat-stm32mp2-save-restore-DDR-encryption-key.patch \
	file://0168-feat-st-drivers-stm32_iwdg-start-the-watchdog-on-sta.patch \
	file://0169-feat-stm32mp2-add-watchdog-support.patch \
	file://0170-feat-stm32mp25-fdts-add-iwdg1-on-eval-board.patch \
	file://0171-feat-stm32mp25-fdts-add-iwdg1-on-dk-board.patch \
	file://0172-feat-stm32mp2-syscfg-Add-delay-block-management-for-.patch \
	file://0173-feat-st-spi-add-OSPI-calibration.patch \
	file://0174-feat-st-spi-allow-to-sample-later-the-data.patch \
	file://0175-feat-mtd-add-hyperflash-framework.patch \
	file://0176-feat-st-spi-add-hyperflash-support.patch \
	file://0177-feat-stm32mp2-add-hyperflash-support.patch \
	file://0178-fix-stm32mp2-fdts-keep-ommanager-for-hyperflash.patch \
	file://0179-feat-mtd-add-DTR-support-in-spi-mem.patch \
	file://0180-feat-mtd-spi_nor-add-octal-DTR-support.patch \
	file://0181-fix-stm32mp2-multiple-fixes-added-for-DTR-support.patch \
	file://0182-feat-st-spi-multiple-fixes-added-for-DTR-support.patch \
	file://0183-feat-mtd-add-reset-callback.patch \
	file://0184-fix-stm32mp2-flush-data-cache-at-the-end-of-BL2.patch \
	file://0185-feat-stm32mp2-add-IO-exit-API.patch \
	file://0186-feat-optee-add-a-new-function-opteed_restore.patch \
	file://0187-feat-stm32mp2-add-support-for-PSCI_OS_INIT_MODE.patch \
	file://0188-feat-stm32mp2-keep-RETRAM-in-Standby-mode.patch \
	file://0189-feat-stm32mp2-restore-context-after-standby.patch \
	file://0190-fix-stm32mp2-correctly-handle-STANDBY.patch \
	file://0191-feat-stm32mp2-add-IAC-defines.patch \
	file://0192-feat-stm32mp2-add-add-a-function-to-set-ICN-QOS.patch \
	file://0193-feat-stm32mp2-tune-interconnect-bandwidth.patch \
	file://0194-feat-stm32mp21-stub-GPU-and-VENC-BW-limiter-on-STM32.patch \
	file://0195-fix-psci-fix-power-level-for-CPU-off-with-OSI.patch \
	file://0196-feat-stm32mp2-save-gicv2-configuration-for-STOP2-mod.patch \
	file://0197-feat-stm32mp2-add-function-plat_get_target_pwr_state.patch \
	file://0198-feat-psci-fix-psci_update_req_local_pwr_states.patch \
	file://0199-feat-stm32mp2-introduce-STM32MP_M33_TDCID-flag.patch \
	file://0200-feat-stm32mp2-stub-DDR-configuration-when-not-TDCID.patch \
	file://0201-feat-stm32mp2-stub-some-features-when-not-TDCID.patch \
	file://0202-fix-stm32mp2-put-crash-console-clocks-under-TDCID-fl.patch \
	file://0203-feat-stm32mp2-add-OTP-functions-M33-TDCID.patch \
	file://0204-feat-st-clock-stub-some-registers-access-when-not-TD.patch \
	file://0205-feat-psci-add-PLAT_MIN_SUSPEND_PWR_LVL.patch \
	file://0206-feat-stm32mp2-verify-power-mode-for-suspend-request.patch \
	file://0207-feat-gicv2-add-gicv2_distif_save-restore-functions.patch \
	file://0208-feat-st-add-stm32mp_gic_save-resume-functions.patch \
	file://0209-feat-stm32mp2-display-pending-IAC-in-BL2-entry.patch \
	file://0210-feat-stm32mp2-clear-all-IAC-when-serial-programmer-i.patch \
	file://0211-fix-stm32mp2-skip-iac_dump-when-M33-is-TDCID.patch \
	file://0212-feat-stm32mp1-check-the-backup-ram-access.patch \
	file://0213-feat-stm32mp15-allow-Backup-SRAM-access-after-tamper.patch \
	file://0214-feat-stm32mp2-Mask-potential-tamper-during-FSBL-exec.patch \
	file://0215-feat-stm32mp2-fdts-add-nvram-NVMEM-node-under-tamp-i.patch \
	file://0216-feat-stm32mp13-fdts-add-nvram-NVMEM-node-under-tamp-.patch \
	file://0217-feat-stm32mp15-fdts-add-nvram-NVMEM-node-under-tamp-.patch \
	file://0218-feat-st-nvmem-add-nvmem-framework.patch \
	file://0219-feat-st-add-support-for-TAMP-backup-registers.patch \
	file://0220-feat-st-use-NVMEM-framework-instead-of-direct-reg-ac.patch \
	file://0221-feat-st-add-check-to-function-linked-to-NVMEM.patch \
	file://0222-feat-st-rework-FWU-to-consider-trial-counter-0-as-un.patch \
	file://0223-fix-st-prevent-try_cnt-from-being-decremented-below-.patch \
	file://0224-fix-stm32mp2-update-pwr_domain_suspend.patch \
	file://0225-feat-stm32mp2-map-DDR-part-non-secure-when-M33-is-TD.patch \
	file://0226-feat-stm32mp2-skip-ICN-configuration-if-M33-is-TDCID.patch \
	file://0227-feat-stm32mp2-remove-RISAF-config-for-M33-TDCID.patch \
	file://0228-feat-stm32mp1-add-intrusion-alert-upon-tamper-event-.patch \
	file://0229-feat-stm32mp2-add-intrusion-alert-upon-tamper-event-.patch \
	file://0230-fix-stm32mp2-remove-Tamper-access-when-M33-is-TDCID.patch \
	file://0231-feat-st-crypto-check-if-SAES-is-already-initialized.patch \
	file://0232-fix-st-crypto-adapt-kshareid-values-for-STM32MP25.patch \
	file://0233-feat-st-crypto-add-STM32MP21-SAES-driver-support.patch \
	file://0234-feat-stm32mp21-enable-crypto-peripherals-on-STM32MP2.patch \
	file://0235-refactor-st-crypto-split-RNG-NIST-configuration.patch \
	file://0236-feat-st-crypto-manage-RNG-customization-with-device-.patch \
	file://0237-feat-st-crypto-improve-RNG-parameter-for-all-platfor.patch \
	file://0238-fix-st-crypto-increase-RNG-robustness-for-STM32MP21.patch \
	file://0239-fix-stm32mp2-correct-stm32_system_off.patch \
	file://0240-refactor-st-use-c-to-display-board-info.patch \
	file://0241-feat-efi-add-metadata-GUID-define.patch \
	file://0242-feat-st-add-specific-GUIDs-for-metadata-partitions.patch \
	file://0243-feat-partition-add-function-to-retrieve-entry-by-par.patch \
	file://0244-feat-st-add-GUID-support-for-metadata-partition-sele.patch \
	file://0245-feat-stm32mp21-disable-PWR_CPU3CR-and-PWR_D3CR-acces.patch \
	file://0246-feat-stm32mp21-disable-RCC_C1P1RSTCSETR-access-on-ST.patch \
	file://0247-feat-stm32mp21-disable-PWR_CPU3D3SR-access-on-STM32M.patch \
	file://0248-feat-stm32mp21-disable-PWR_D3CR-access-on-STM32MP21.patch \
	file://0249-feat-st-spi-Add-the-support-of-the-SFDP-calibration.patch \
	file://0250-refactor-stm32mp25-fdts-rename-IOM-EVAL-pins-muxing-.patch \
	file://0251-feat-stm32mp2-add-UART-Programmer-support.patch \
	file://0252-fix-stm32mp2-fix-the-LP-Stop2-and-LPLV-Stop2.patch \
	file://0253-feat-stm32mp2-add-fdt-address-in-low-power-context.patch \
	file://0254-feat-stm32mp2-optimize-the-wake-up-time-for-low-powe.patch \
	file://0255-feat-stm32mp1-remove-stop-watchdog-when-going-in-low.patch \
	file://0256-feat-stm32mp2-remove-function-stm32_iwdg_shadow_upda.patch \
	file://0257-feat-st-iwdg-remove-unused-flags.patch \
	file://0258-feat-st-iwdg-set-watchdog-timeout-from-DT.patch \
	file://0259-feat-st-spi-add-OSPI-support-for-MP21.patch \
	file://0260-feat-st-clock-add-dmb-dsb-in-clock-driver.patch \
	file://0261-feat-stm32mp2-pwr-syscfg-skip-none-existent-STM32MP2.patch \
	file://0262-fix-stm32mp2-maintain-LPSRAM1-content-in-standby-mod.patch \
	file://0263-feat-stm32mp2-display-package-type-for-STM32MP21.patch \
	file://0264-feat-stm32mp2-support-running-M33-for-low-power-mode.patch \
	file://0265-feat-st-clock-add-stm32mp2-pll1-functions-for-stm32m.patch \
	file://0266-fix-stm32mp2-restore-PLL1-settings-after-STOP2-modes.patch \
	file://0267-feat-st-clock-rename-stm32mp2_a35_ss_on_hsi.patch \
	file://0268-feat-stm32mp2-call-the-OP-TEE-SPD-cpu-suspend-handle.patch \
	file://0269-feat-stm32mp2-add-OTP-mirror-read-code.patch \
	file://0270-refactor-st-clock-move-oscillators-ops-from-clk-stm3.patch \
	file://0271-fix-st-clock-increase-startup-timeout-for-oscillator.patch \
	file://0272-fix-st-clock-increase-startup-timeout-for-oscillator.patch \
	file://0273-feat-stm32mp2-update-BSEC-fuse-map-for-STM32MP21.patch \
	file://0274-feat-stm32mp2-manage-OTP-mirror-area.patch \
	file://0275-feat-stm32mp2-change-PKH_OTP-value-for-STM32MP21.patch \
	file://0276-fix-stm32mp2-remove-all-set-of-gpio-secure-in-M33TD-.patch \
	file://0277-feat-stm32mp21-check-HWKEY-validity-before-writing-R.patch \
	file://0278-feat-stm32mp2-update-a-ca35ss-driver.patch \
	file://0279-fix-stm32mp2-isolate-STGEN-in-low-power.patch \
	file://0280-feat-stm32mp2-force-autonomous-mode-for-LPSRAM1-2-3-.patch \
	file://0281-Trace-in-stm32_get_sys_suspend_power_state.patch \
	file://0282-feat-stm32mp2-fix-CPU1-wake-up-from-RUN2.patch \
	file://0283-feat-stm32mp2-fix-shutdown-on-STM32MP21.patch \
	file://0284-feat-stm32mp2-support-cortex-M33-as-TDCID-in-STM32MP.patch \
	file://0285-feat-st-clock-test-if-clock-is-already-enabled.patch \
	file://0286-fix-st-clock-remove-mux-access-when-m33tdcid.patch \
	file://0287-feat-stm32mp2-disable-RNG-init-when-M33-is-TDCID.patch \
	file://0288-feat-stm32mp2-add-synchronization-point-between-CA35.patch \
	file://0289-fix-st-clock-remove-CLK_CFG-CMD_CLK-support-for-st-k.patch \
	file://0290-feat-stm32mp2-increase-extra-partition-for-M33TDCID.patch \
	file://0291-feat-stm32mp2-force-boot-interface-instance-on-M33TD.patch \
	file://0292-fix-stm32mp2-restore-STGEN-before-PLL1-settings-afte.patch \
	file://0293-feat-st-clock-add-ck_sys_dbg-clock-for-STM32MP2.patch \
	file://0294-feat-stm32mp15-fdts-remove-RTC-clocks-for-OP-TEE-con.patch \
	file://0295-feat-st-add-stm32mp_uart_console_is_running.patch \
	file://0296-fix-stm32mp2-disable-console-if-necessary-during-LP-.patch \
	file://0297-feat-stm32mp2-support-cortex-M33-as-TDCID-in-STM32MP.patch \
	file://0298-fix-stm32mp2-fix-CID-filtering-for-PWR_CPU2CR.patch \
	file://0299-fix-stm32mp2-fix-CID-filtering-for-EXTI2_CmIMRx.patch \
	file://0300-fix-stm32mp2-fix-shutdown-on-STM32MP21.patch \
	file://0301-fix-stm32mp2-remove-warning-in-stm32_system_off.patch \
	file://0302-fix-stm32mp2-authorize-the-LPLV-Stop2-for-GPIO-wakeu.patch \
	file://0303-fix-fdts-set-flexgen-58-to-HSE_KER-for-STM32MP257F-E.patch \
	file://0304-fix-psci-Allow-return-to-aarch32-smc-caller.patch \
	file://0305-feat-st-clock-add-trace-for-unknown-clock-identifier.patch \
	file://0306-feat-stm32mp2-boot-BL33-at-EL2-by-default.patch \
	file://0307-feat-stm32mp2-workaround-implementation-for-D1-D2-lo.patch \
	file://0308-refactor-stm32mp2-make-stm32_pwr_cpu2_state_is_runni.patch \
	file://0309-feat-st-bsec-add-support-of-HDPL-for-STM32MP21.patch \
	file://0310-feat-st-bsec-add-support-of-HDPL-increment-in-M33TD.patch \
	file://0311-fix-st-bsec-update-bsec-state-to-match-other-compone.patch \
	file://0312-feat-stm32mp2-increment-HDPL-before-booting-BL31.patch \
	file://0313-fix-stm32mp2-save-lpsram_amen-in-low-power-context.patch \
	file://0314-fix-stm32mp2-remove-stm32mp2_ddr_helpers-for-M33-TDC.patch \
	file://0315-feat-stm32mp2-update-stm32mp_system_reset-for-M33-TD.patch \
	file://0316-feat-fdts-update-SPI-NOR-partition-offsets-for-M33TD.patch \
	file://0317-feat-stm32mp2-support-CPU1-reset-for-M33-TDCID.patch \
	file://0318-fix-stm32mp2-clear-low-power-context-on-standby-exit.patch \
	file://0319-feat-stm32mp2-add-sanity-check-in-low-power-context.patch \
	file://0320-feat-stm32mp1-add-crc-in-low-power-mode-context.patch \
	file://0321-fix-stm32mp2-support-cortex-M33-as-TDCID-in-STM32MP2.patch \
	file://0322-fix-stm32mp2-restore-system-for-warmboot-after-D1-DS.patch \
	file://0323-feat-st-rework-setup-of-SVC-services.patch \
	file://0324-feat-stm32mp2-add-CPU-compatible-define.patch \
	file://0325-feat-st-export-stm32mp_get_part_number.patch \
	file://0326-feat-st-add-SMC-error-codes-on-going-and-no-perm.patch \
	file://0327-feat-st-clock-export-needed-functions-for-ca35ss_clk.patch \
	file://0328-feat-stm32mp2-add-SMC-services-for-CA35SS-clock-scal.patch \
	file://0329-feat-stm32mp2-register-SMC-services-for-CA35SS-clock.patch \
	file://0330-feat-st-use-BL33-parameter-x0-for-physical-address-o.patch \
	file://0331-refactor-st-sdmmc2-data-timeout-calculation-based-on.patch \
	file://0332-feat-st-allow-booting-Linux-directly.patch \
	file://0333-feat-stm32mp2-pwr-syscfg-allow-to-set-a-fixed-IO-com.patch \
	file://0334-feat-stm32mp2-fdts-add-fixed-IO-compensation-on-vddi.patch \
	file://0335-feat-stm32mp2-fdts-add-fixed-IO-compensation-on-vddi.patch \
	file://0336-feat-stm32mp2-fdts-add-fixed-IO-compensation-on-vddi.patch \
	file://0337-feat-stm32mp2-add-SCMI-secure-shmem-in-memory-map-fo.patch \
	file://0338-feat-stm32mp2-add-IPCC-base-addresses.patch \
	file://0339-feat-stm32mp2-add-simple-a-simple-SCMI-voltd-client-.patch \
	file://0340-feat-stm32mp2-add-support-for-CA35SS-voltage-scaling.patch \
	file://0341-feat-st-add-RSE-comms-support-for-ST-platforms.patch \
	file://0342-feat-stm32mp2-enable-rse-support.patch \
	file://0343-feat-stm32mp2-add-M33TDCID-secure-boot-support.patch \
	file://0344-fix-stm32mp2-increase-stack-size-when-Mbed-TLS-is-us.patch \
	file://0345-feat-stm32mp2-enable-LTO-support-in-STM32MP2.patch \
	file://0346-feat-st-clock-force-clock-tree-for-Stop2-low-power-m.patch \
	file://0347-fix-st-clock-don-t-change-flexgen-for-CM33-TDCID-on-.patch \
	file://0348-fix-stm32mp2-fix-system-off-on-STM32MP25.patch \
	file://0349-fix-stm32mp2-flush-the-console-when-going-in-suspend.patch \
	file://0350-fix-stm32mp2-Manage-D3-autonomous-clocking-workaroun.patch \
	file://0351-fix-stm32mp2-support-cortex-M33-as-TDCID-in-STM32MP2.patch \
	file://0352-fix-stm32mp2-maintain-only-BKPSRAM-content-in-power-.patch \
	file://0353-feat-stm32mp2-add-DDR-power-OFF-function.patch \
	file://0354-feat-stm32mp2-call-stm32mp_board_ddr_power_off-in-po.patch \
	file://0355-docs-dt-bindings-add-device-tree-bindings-used-on-ST.patch \
	file://0356-refactor-st-crypto-add-a-crypto-common-header.patch \
	file://0357-feat-st-crypto-add-AES-decrypt-auth-by-CRYP-peripher.patch \
	file://0358-refactor-stm32mp2-update-rif.h-to-meet-MISRA-expecta.patch \
	file://0359-feat-stm32mp2-configure-RIFSC-to-manage-CRYP1-in-the.patch \
	file://0360-feat-psa-add-standard-IOCTL-RSE-call.patch \
	file://0361-feat-stm32mp2-add-stm32mp-rse-comm-specific-function.patch \
	file://0362-feat-stm32mp2-add-M33TDCID-encrypted-boot-support.patch \
	file://0363-feat-stm32mp2-add-stm32mp_ca35_configure_opp.patch \
	file://0364-feat-st-clock-add-the-needed-function-for-ca35ss_clk.patch \
	file://0365-feat-stm32mp2-fix-support-for-CA35SS-voltage-scaling.patch \
	file://0366-feat-drivers-scmi-add-define-for-SCMI-protocol-17.patch \
	file://0367-fix-stm32mp2-fix-scmi-driver.patch \
	file://0368-feat-stm32mp2-rework-SCMI-driver.patch \
	file://0369-feat-stm32mp2-add-support-of-token-in-SCMI-messages.patch \
	file://0370-feat-stm32mp2-add-SCMI-system-power-management-proto.patch \
	file://0371-feat-stm32mp2-use-SCMI-power-state-protocol-for-CM33.patch \
	file://0372-feat-stm32mp2-set-DDR-in-self-refresh-in-system-off-.patch \
	file://0373-feat-bl31-add-delete_interrupt_type_handler-function.patch \
	file://0374-fix-stm32mp2-handle-power-down-on-secondary-core.patch \
	file://0375-feat-stm32mp-add-stack-protector-support.patch \
	file://0376-perf-st-spi-improve-memory-mapped-read-throughput.patch \
	file://0377-perf-st-spi-improve-indirect-read-write-throughput.patch \
	file://0378-perf-stm32mp2-fdts-set-OSPI-clock-at-266-MHz-when-ne.patch \
	file://0379-perf-st-spi-improve-memory-mapped-read-throughput.patch \
	file://0380-perf-st-spi-improve-indirect-read-write-throughput.patch \
	file://0381-feat-clk-support-multiple-clock-providers-via-clock-.patch \
	file://0382-feat-st-clock-use-clk_add_default_provider-to-regist.patch \
	file://0383-feat-fdt-wrappers-fdt_get_phandle_with_args-function.patch \
	file://0384-feat-st-add-interface-to-get-a-clock-by-an-index-fro.patch \
	file://0385-feat-clk-introduce-support-of-fixed-clock.patch \
	file://0386-feat-stm32mp2-register-all-fixed-clocks-at-startup.patch \
	file://0387-feat-st-spi-add-fixed-clock-support-in-stm32_ospi_in.patch \
	file://0388-feat-stm32mp2-fix-shmem-channel-status-read-access.patch \
	file://0389-fix-stm32mp2-increase-scmi-timeout.patch \
	file://0390-fix-stm32mp2-change-scmi-system-power-request-to-for.patch \
	file://0391-feat-st-clock-do-not-disable-clock-when-M33-is-TDCID.patch \
	file://0392-fix-compiler-rt-force-usage-of-__popcountdi2.patch \
	file://0393-refactor-stm32mp1-print-reset-reason-at-a-lower-log-.patch \
	file://0394-refactor-stm32mp2-print-reset-reason-at-a-lower-log-.patch \
	file://0395-fix-stm32mp2-configure-STOP2-entry-point-when-needed.patch \
	file://0396-fix-stm32mp1-increase-STM32MP_BL2_SIZE.patch \
	file://0397-feat-stm32mp1-set-stm32_pwr_down_wfi_wrapper-multipr.patch \
	file://0398-feat-stm32mp1-filter-mode-in-stm32_pwr_down_wfi_load.patch \
	file://0399-feat-stm32mp1-add-PSCI-OSI-low-power-request.patch \
	file://0400-fix-stm32mp1-use-GIC-in-BL2.patch \
	file://0401-feat-stm32mp1-implement-a-wake-up-of-the-primary-CPU.patch \
	file://0402-fix-stm32mp15-increase-BL2-size-when-using-SP_min.patch \
	file://0403-feat-fdts-add-DDR4-1x16Gbit-1x16bit-1200MHz-configur.patch \
	file://0404-feat-st-add-ST-specific-version.patch \
	file://0405-feat-st-bsec-export-BSEC-function-for-SSP.patch \
	file://0406-feat-st-add-SSP-support-for-STM32CubeProgrammer.patch \
	file://0407-feat-stm32mp1-add-a-regulator-supply-function-for-sy.patch \
	file://0408-feat-stm32mp1-add-secure-secret-provisioning.patch \
	file://0409-fix-stm32mp1-check-for-the-correct-vddcore-regulator.patch \
	file://0410-feat-st-update-SSP-for-stm32mp13-platform.patch \
	file://0411-fix-stm32mp1-ssp-improve-SSP-robustness-and-allow-to.patch \
	file://0412-feat-stm32mp1-fdts-remove-useless-delete-node-proper.patch \
	file://0413-feat-stm32mp1-fdts-add-sysram-node-for-ssp.patch \
	file://0414-fix-stm32mp1-fix-uart-download-issue-on-console.patch \
	file://0415-fix-stm32mp1-stub-some-code-for-SSP.patch \
	file://0416-fix-stm32mp2-correct-ORR-instruction-in-plat_crash_c.patch \
	file://0417-fix-st-ddr-add-missing-n-in-error-trace.patch \
	file://0418-refactor-stm32mp2-simplify-stm32_pm_init.patch \
	file://0419-feat-stm32mp2-add-synchronization-point-between-CA35.patch \
	file://0420-feat-stm32mp2-add-specific-BL2-size-for-M33TD.patch \
	file://0421-feat-stm32mp2-support-of-previous-STM32MP23-25-revis.patch \
	file://0422-fix-st-update-stm32image-tool-to-address-Coverity-is.patch \
	file://0423-feat-stm32mp2-fdts-add-TAMP-backup-register-node-for.patch \
	file://0424-feat-st-add-helper-to-access-Cortex-M-firmware-updat.patch \
	file://0425-feat-st-add-sync-mechanism-for-asymmetrical-firmware.patch \
	file://0426-fix-stm32mp2-fdts-fix-LPDDR4-16bits-swizzle.patch \
	file://0427-fix-st-rif-do-not-assign-an-unused-value-for-node-wh.patch \
	file://0428-fix-st-nvmem-check-fdt_node_offset_by_phandle-return.patch \
	file://0429-fix-st-clock-do-not-include-platform_def.h.patch \
	file://0430-fix-st-clock-do-not-return-NULL-in-_clk_get.patch \
	file://0431-fix-st-clock-remove-some-variables-default-assignmen.patch \
	file://0432-fix-st-clock-check-fdt_subnode_offset-return.patch \
	file://0433-fix-stm32mp2-cast-values-to-uint32_t-before-shifting.patch \
	file://0434-fix-stm32mp2-check-index-before-accessing-the-PM-tab.patch \
	file://0435-fix-st-check-return-values-of-NVMEM-functions.patch \
	file://0436-fix-st-ddr-fix-coverity-static-analysis-issues.patch \
	file://0437-feat-stm32mp2-set-VREF-and-VTT-regulators-as-optiona.patch \
	file://0438-feat-stm32mp2-add-a-cold-boot-detection-indication.patch \
	file://0439-feat-stm32mp1-add-a-cold-boot-detection-indication.patch \
	file://0440-fix-psci-check-error-value-for-psci_find_target_susp.patch \
	file://0441-fix-stm32mp2-cast-ST_CTX_VER_MAJOR-for-ST_CTX_VERSIO.patch \
	file://0442-fix-stm32mp2-add-a-check-on-fdt_get_address-when-sav.patch \
	file://0443-fix-stm32mp2-skip-minor-version-check-if-it-is-0.patch \
	file://0444-fix-st-pmic-check-stpmic2_is_buck1_high_voltage-retu.patch \
	file://0445-fix-st-pmic-initialize-some-structs-in-dt_pmic2_i2c_.patch \
	file://0446-refactor-st-remove-unused-GPIO-regulator-driver.patch \
	file://0447-fix-st-spi-Avoid-using-uninitialized-value.patch \
	file://0448-fix-stm32mp2-disable-programmer-UART-before-changing.patch \
	file://0449-fix-stm32mp2-reset-USB-in-UART-programmer-mode.patch \
	file://0450-feat-st-keep-TAMP_BKP_REG_CLK-always-on.patch \
	file://0451-fix-st-ddr-fix-coverity-static-analysis-issues.patch \
	file://0452-fix-stm32mp2-remove-unused-code-in-stm32_pwr_domain_.patch \
	file://0453-fix-st-nvmem-Fix-an-overflow-in-stm32_tamp_nvram_rea.patch \
	file://0454-fix-stm32mp2-manage-DDR-data-cache-for-M33-TD-flavor.patch \
	file://0455-refactor-stm32mp2-update-defines-for-32-bit-register.patch \
	file://0456-fix-st-clock-improve-clock-enabling-disabling-barrie.patch \
	file://0457-fix-st-pmic-check-volt_table-in-stpmic2_regulator_ge.patch \
	file://0458-fix-stm32mp2-check-core_id-in-stm32mp_state_set.patch \
	file://0459-fix-stm32mp2-fix-Coverity-issue-in-print_reset_reaso.patch \
	file://0460-fix-st-remove-redundant-fd-initializations-in-stm32i.patch \
	file://0461-fix-st-spi-avoid-overflow-in-stm32_ospi_dtr_calibrat.patch \
	file://0462-fix-st-spi-cast-the-number-of-banks-from-DT-to-uint8.patch \
	file://0463-fix-stm32mp2-fix-debug-clock-ID-used-for-TSGEN-isola.patch \
	file://0464-fix-st-ddr-disabled-DDR-bus-clock.patch \
	file://0465-fix-stm32mp2-no-more-disable-DDR-in-low-power.patch \
	file://0466-feat-stm32mp2-add-CK_KER_TSDBG-clock-support.patch \
	file://0467-feat-stm32mp15-fdts-add-stm32mp157d-boards.patch \
	file://0468-feat-stm32mp15-fdts-add-stm32mp157d-dk1-board.patch \
	file://0469-feat-stm32mp15-fdts-add-SoC-DT-files.patch \
	file://0470-fix-st-drivers-guard-MCE-PM-context-calls.patch \
	file://0471-feat-stm32mp2-add-DDR-PHY-FW-files-for-MP2.patch \
	file://0472-fix-st-ddr-do-not-panic-on-ddrphy_init-error-during-.patch \
	file://0473-fix-stm32mp2-wait-ARM-timer-to-increment-after-stopp.patch \
	file://0474-fix-stm32mp2-preserve-warmboot-entrypoint-across-STA.patch \
	file://0475-fix-stm32mp2-flush-cache-at-the-beginning-of-bl2_el3.patch \
	file://0476-fix-io-create-a-NULL_UUID-macro.patch \
	file://0477-fix-psci-initialize-last_at_pwrlvl.patch \
	file://0478-fix-platforms-check-MIN_SGI_ID-at-compile-time.patch \
	file://0479-fix-el3-runtime-add-missing-prototypes.patch \
	file://0480-fix-st-make-STM32MP1X-STM32MP2X-boolean-flags.patch \
	file://0481-fix-use-ifdef-for-IMAGE_BL-flags.patch \
	file://0482-fix-use-ifdef-for-__aarch64__-flags.patch \
	file://0483-fix-use-ifdef-PLAT_RO_XLAT_TABLES.patch \
	file://0484-fix-el3-runtime-improve-PLAT_PCPU_DATA_SIZE-check.patch \
	file://0485-fix-cpus-check-__clang_major__-is-defined.patch \
	file://0486-fix-sdei-move-SDEI_SUPPORT-flag-management-in-Makefi.patch \
	file://0487-fix-partition-check-definition-of-platform-flags.patch \
	file://0488-fix-build-move-USE_GIC_DRIVER-flag-management-in-Mak.patch \
	file://0489-fix-build-move-SMC_PCI_SUPPORT-flag-management-to-Ma.patch \
	file://0490-fix-context-mgmt-include-gicv3.h-only-when-needed.patch \
	file://0491-fix-errata-abi-check-REPORT_ERRATA-definition.patch \
	file://0492-fix-st-clock-correct-some-STM32MP15-clock-driver-fun.patch \
	file://0493-fix-stm32mp1-disable-STM32MP2-flags.patch \
	file://0494-fix-stm32mp2-force-STM32MP_STPMIC1L-disabling.patch \
	file://0495-fix-common-manage-signedness-of-next-image-index.patch \
	file://0496-fix-mmc-use-GENMASK_32-in-sd_switch.patch \
	file://0497-fix-opteed-use-correct-return-type-for-opteed_synchr.patch \
	file://0498-fix-opteed-always-evaluate-OPTEE_ALLOW_SMC_LOAD-and-.patch \
	file://0499-fix-opteed-fix-several-clang-Wshorten-64-to-32-warni.patch \
	file://0500-fix-cpufeat-correct-AMU-function-prototypes.patch \
	file://0501-fix-st-cast-the-read_cntfrq_el0-return-to-unsigned-i.patch \
	file://0502-fix-st-bsec-use-BIT_32-in-otp_bit_mask.patch \
	file://0503-fix-st-drivers-use-BIT_32-GENMASK_32-in-ST-drivers.patch \
	file://0504-fix-st-cast-clk_get_rate-return-when-setting-console.patch \
	file://0505-fix-st-sdmmc2-update-plat_sdmmc2_use_dma-prototype.patch \
	file://0506-fix-st-pmic-stub-some-functions-for-STM32MP_STPMIC1L.patch \
	file://0507-fix-st-regulator-remove-const-for-driver_data.patch \
	file://0508-fix-st-pmic-store-regulator-ID-as-an-uint8_t.patch \
	file://0509-fix-st-guard-console_clk-usage-before-initialization.patch \
	file://0510-fix-st-pmic-remove-unused-function-stpmic2_set_prop.patch \
	file://0511-fix-st-pmic-remove-stm32mp_pmic2.h.patch \
	file://0512-feat-stm32mp2-Add-system-power-controller-support-fo.patch \
	file://0513-feat-stm32mp1-fdts-Use-a-generic-name-for-the-PMIC-n.patch \
	file://0514-feat-stm32mp2-fdts-Use-a-generic-name-for-the-PMIC-n.patch \
	file://0515-feat-stm32mp2-use-scmi-system-power-request-for-syst.patch \
	file://0516-fix-stm32mp2-check-size-of-context-in-backup-SRAM.patch \
	file://0517-fix-stm32mp2-drop-the-wfi-from-stm32mp_pwr_domain_pw.patch \
	file://0518-fix-stm32mp1-drop-the-wfi-from-stm32mp_pwr_domain_pw.patch \
	file://0519-fix-st-usb-make-register_usb_driver-and-register_pla.patch \
	file://0520-fix-st-usb-change-prototype-of-usb_dwc3_init_driver.patch \
	file://0521-fix-st-usb-rename-some-global-variables.patch \
	file://0522-fix-st-usb-void-variables-instead-of-using-__unused.patch \
	file://0523-fix-st-usb-use-const-pointers-for-function-parameter.patch \
	file://0524-fix-st-usb-move-usb_dwc3driver-inside-usb_dwc3_init_.patch \
	file://0525-fix-st-usb-avoid-unreachable-statement-in-dwc3_execu.patch \
	file://0526-fix-st-usb-avoid-dead-code-in-dwc3_read_dev_evt_type.patch \
	file://0527-fix-st-usb-update-__HAL_PCD_EPADDR_TO_PHYEPNUM-macro.patch \
	file://0528-fix-st-usb-remove-useless-asserts.patch \
	file://0529-fix-st-usb-check-that-endoint-number-does-not-overfl.patch \
	file://0530-fix-stm32mp2-set-FWU-boot-index-before-BL2-DT-is-ove.patch \
	file://0531-feat-st-add-extended-bootloader-GUID.patch \
	file://0532-feat-st-add-Linux-data-partition-GUID.patch \
	file://0533-feat-st-add-STM32MP_PSA_FWU_AB_SUPPORT-build-flag.patch \
	file://0534-feat-st-enable-A-B-redundancy-support.patch \
	file://0535-feat-st-add-a-halt-on-panic-flag.patch \
	file://0536-fix-st-spi-move-OSPI-driver-to-latest-bindings.patch \
	file://0537-fix-stm32mp2-fdts-move-SoC-dtsi-to-latest-OMM-OSPI-b.patch \
	file://0538-fix-stm32mp2-fdts-move-EV1-board-to-latest-OMM-OSPI-.patch \
	file://0539-fix-stm32mp2-correct-IO-domain-status-check.patch \
	file://0540-stm32mp-pwr-enable-VDDIO-domain-for-always-on-regula.patch \
	file://0541-fix-stm32mp1-keep-PLL1-settings-in-context-only-for-.patch \
	file://0542-docs-dt-bindings-fix-device-tree-bindings-used-on-ST.patch \
	file://0543-feat-st-update-platform-core-count-for-ST-platform.patch \
	file://0544-fix-dt-bindings-fix-the-low-power-defines-for-STM32M.patch \
	file://0545-fix-dt-bindings-remove-unused-stm32mp1-pwr-propertie.patch \
	file://0546-fix-stm32mp2-force-panic-halt-when-M33-TDCID-is-enab.patch \
	file://0547-feat-psci-add-a-flag-to-allow-PSCI-calls-from-secure.patch \
	file://0548-refactor-st-add-an-explicit-error-if-BL33_CFG-is-not.patch \
	file://0549-feat-st-manage-secure-application-firmware.patch \
	file://0550-fix-st-crypto-use-static-CLKDIV-for-RNG-on-MP2x-plat.patch \
	file://0551-feat-stm32mp2-stub-PM-code-in-serial-boot-for-OSI-su.patch \
	file://0552-feat-stm32mp2-abort-power-down-for-Stop2-on-pending-.patch \
	file://0553-feat-stm32mp1-allow-overriding-secure-DDR-size.patch \
	file://0554-fix-st-remove-duplicate-OTP-nodes-from-stm32mp13-ssp.patch \
	file://0555-fix-fwu-add-newline-characters-in-warning-messages.patch \
	file://0556-feat-fwu-relax-metadata-validation-for-image-count-a.patch \
	file://0557-feat-st-search-FIP-entry-explicitly-in-plat_fwu_set_.patch \
	file://0558-refactor-st-drop-unused-A-B-bootfs-rootfs-IO-policie.patch \
	file://0559-fix-st-pmic-initialize-state-in-stpmic2_dump_regulat.patch \
	file://0560-plat-stm32mp2-preserve-RETRAMCR-bits-when-disabling-.patch \
	file://0561-plat-stm32mp2-add-stm32mp_init_retram.patch \
	file://0562-fix-st-bound-check-image-ID-in-plat_get_image_source.patch \
	file://0563-fix-stm32mp2-ignore-intentional-USB-reset-assert-ret.patch \
	file://0564-fix-stm32mp2-return-an-SMC-status-on-PLL1-set-rate-f.patch \
	file://0565-fix-stm32mp-erase-MbedTLS-heap-before-BL2-exit.patch \
	file://0566-fix-st-pmic-select-PMIC-driver-per-STM32MP_STPMIC1L-.patch \
	file://0567-feat-st-propose-a-legacy-version-of-DDR_FW_HASH_OID.patch \
	file://0568-fix-stm32mp2-update-support-for-PSCI_OS_INIT_MODE.patch \
	file://0569-fix-psci-ignore-pending-FIQs-during-CPU_SUSPEND.patch \
	file://0570-fix-mmc-increase-MMC_DEFAULT_MAX_RETRIES.patch \
	file://0571-fix-stm32mp2-enable-VDDIO3SV-and-VDDIO4SV.patch \
	file://0572-feat-stm32mp2-add-support-for-STM32MP23xx-STM32MP25x.patch \
"
